Properties of the parts of a building model (IFC4X3_ADD2), part 4 of 9

# IfcGeographicElement: 산철쭉 H0.8 X W0.8 (160)
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_R03-017 | 관목 개체 / P2_R03-017 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-017 | B | {"type": "Point", "coordinates": [23.648125000000007, 44.96005568643355]} | 1.05456 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-018 | 관목 개체 / P2_R03-018 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-018 | B | {"type": "Point", "coordinates": [24.49812500000001, 44.96005568643355]} | 1.04181 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-019 | 관목 개체 / P2_R03-019 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-019 | B | {"type": "Point", "coordinates": [25.34812500000001, 44.96005568643355]} | 1.02906 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-020 | 관목 개체 / P2_R03-020 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-020 | B | {"type": "Point", "coordinates": [26.19812500000001, 44.96005568643355]} | 1.01631 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-021 | 관목 개체 / P2_R03-021 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-021 | B | {"type": "Point", "coordinates": [27.048125000000013, 44.96005568643355]} | 1.00356 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-022 | 관목 개체 / P2_R03-022 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-022 | B | {"type": "Point", "coordinates": [27.898125000000014, 44.96005568643355]} | 0.990809 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-023 | 관목 개체 / P2_R03-023 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-023 | B | {"type": "Point", "coordinates": [28.748125000000016, 44.96005568643355]} | 0.978059 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-024 | 관목 개체 / P2_R03-024 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-024 | B | {"type": "Point", "coordinates": [29.598125000000017, 44.96005568643355]} | 0.965309 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-025 | 관목 개체 / P2_R03-025 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-025 | A | {"type": "Point", "coordinates": [8.773125, 45.69617727965032]} | 1.29093 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-026 | 관목 개체 / P2_R03-026 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-026 | A | {"type": "Point", "coordinates": [9.623125, 45.69617727965032]} | 1.27818 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-027 | 관목 개체 / P2_R03-027 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-027 | A | {"type": "Point", "coordinates": [10.473125, 45.69617727965032]} | 1.26543 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-028 | 관목 개체 / P2_R03-028 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-028 | A | {"type": "Point", "coordinates": [11.323125, 45.69617727965032]} | 1.25268 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-029 | 관목 개체 / P2_R03-029 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-029 | A | {"type": "Point", "coordinates": [12.173124999999999, 45.69617727965032]} | 1.23993 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-030 | 관목 개체 / P2_R03-030 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-030 | A | {"type": "Point", "coordinates": [13.023124999999999, 45.69617727965032]} | 1.22718 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-031 | 관목 개체 / P2_R03-031 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-031 | A | {"type": "Point", "coordinates": [13.873124999999998, 45.69617727965032]} | 1.21443 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-032 | 관목 개체 / P2_R03-032 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-032 | A | {"type": "Point", "coordinates": [14.723124999999998, 45.69617727965032]} | 1.20168 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-033 | 관목 개체 / P2_R03-033 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-033 | A | {"type": "Point", "coordinates": [15.573124999999997, 45.69617727965032]} | 1.18893 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-034 | 관목 개체 / P2_R03-034 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-034 | A | {"type": "Point", "coordinates": [16.423125, 45.69617727965032]} | 1.17618 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-035 | 관목 개체 / P2_R03-035 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-035 | A | {"type": "Point", "coordinates": [17.273125, 45.69617727965032]} | 1.16343 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-036 | 관목 개체 / P2_R03-036 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-036 | A | {"type": "Point", "coordinates": [19.823125000000005, 45.69617727965032]} | 1.12518 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-037 | 관목 개체 / P2_R03-037 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-037 | B | {"type": "Point", "coordinates": [20.673125000000006, 45.69617727965032]} | 1.11243 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-038 | 관목 개체 / P2_R03-038 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-038 | B | {"type": "Point", "coordinates": [21.523125000000007, 45.69617727965032]} | 1.09968 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-039 | 관목 개체 / P2_R03-039 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-039 | B | {"type": "Point", "coordinates": [22.37312500000001, 45.69617727965032]} | 1.08693 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-040 | 관목 개체 / P2_R03-040 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-040 | B | {"type": "Point", "coordinates": [23.22312500000001, 45.69617727965032]} | 1.07418 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-041 | 관목 개체 / P2_R03-041 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-041 | B | {"type": "Point", "coordinates": [24.07312500000001, 45.69617727965032]} | 1.06143 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-042 | 관목 개체 / P2_R03-042 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-042 | B | {"type": "Point", "coordinates": [24.923125000000013, 45.69617727965032]} | 1.04868 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-043 | 관목 개체 / P2_R03-043 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-043 | B | {"type": "Point", "coordinates": [25.773125000000014, 45.69617727965032]} | 1.03593 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-044 | 관목 개체 / P2_R03-044 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-044 | B | {"type": "Point", "coordinates": [26.623125000000016, 45.69617727965032]} | 1.02318 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-045 | 관목 개체 / P2_R03-045 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-045 | B | {"type": "Point", "coordinates": [27.473125000000017, 45.69617727965032]} | 1.01043 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-046 | 관목 개체 / P2_R03-046 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-046 | B | {"type": "Point", "coordinates": [28.32312500000002, 45.69617727965032]} | 0.997684 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-047 | 관목 개체 / P2_R03-047 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-047 | B | {"type": "Point", "coordinates": [29.17312500000002, 45.69617727965032]} | 0.984934 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-048 | 관목 개체 / P2_R03-048 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-048 | B | {"type": "Point", "coordinates": [30.02312500000002, 45.69617727965032]} | 0.972184 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-049 | 관목 개체 / P2_R03-049 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-049 | B | {"type": "Point", "coordinates": [30.873125000000023, 45.69617727965032]} | 0.959434 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-050 | 관목 개체 / P2_R03-050 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-050 | A | {"type": "Point", "coordinates": [8.348125, 46.432298872867094]} | 1.31056 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-051 | 관목 개체 / P2_R03-051 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-051 | A | {"type": "Point", "coordinates": [9.198125, 46.432298872867094]} | 1.29781 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-052 | 관목 개체 / P2_R03-052 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-052 | A | {"type": "Point", "coordinates": [10.048124999999999, 46.432298872867094]} | 1.28506 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-053 | 관목 개체 / P2_R03-053 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-053 | A | {"type": "Point", "coordinates": [10.898124999999999, 46.432298872867094]} | 1.27231 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-054 | 관목 개체 / P2_R03-054 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-054 | A | {"type": "Point", "coordinates": [11.748124999999998, 46.432298872867094]} | 1.25956 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-055 | 관목 개체 / P2_R03-055 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-055 | A | {"type": "Point", "coordinates": [12.598124999999998, 46.432298872867094]} | 1.24681 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-056 | 관목 개체 / P2_R03-056 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-056 | A | {"type": "Point", "coordinates": [13.448124999999997, 46.432298872867094]} | 1.23406 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-057 | 관목 개체 / P2_R03-057 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-057 | A | {"type": "Point", "coordinates": [14.298124999999997, 46.432298872867094]} | 1.22131 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-058 | 관목 개체 / P2_R03-058 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-058 | A | {"type": "Point", "coordinates": [15.148124999999997, 46.432298872867094]} | 1.20856 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-059 | 관목 개체 / P2_R03-059 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-059 | A | {"type": "Point", "coordinates": [15.998124999999996, 46.432298872867094]} | 1.19581 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-060 | 관목 개체 / P2_R03-060 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-060 | A | {"type": "Point", "coordinates": [16.848124999999996, 46.432298872867094]} | 1.18306 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-061 | 관목 개체 / P2_R03-061 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-061 | B | {"type": "Point", "coordinates": [20.248125, 46.432298872867094]} | 1.13206 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-062 | 관목 개체 / P2_R03-062 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-062 | B | {"type": "Point", "coordinates": [21.098125000000003, 46.432298872867094]} | 1.11931 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-063 | 관목 개체 / P2_R03-063 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-063 | B | {"type": "Point", "coordinates": [21.948125000000005, 46.432298872867094]} | 1.10656 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-064 | 관목 개체 / P2_R03-064 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-064 | B | {"type": "Point", "coordinates": [22.798125000000006, 46.432298872867094]} | 1.09381 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-065 | 관목 개체 / P2_R03-065 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-065 | B | {"type": "Point", "coordinates": [23.648125000000007, 46.432298872867094]} | 1.08106 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-066 | 관목 개체 / P2_R03-066 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-066 | B | {"type": "Point", "coordinates": [28.748125000000016, 46.432298872867094]} | 1.00456 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-067 | 관목 개체 / P2_R03-067 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-067 | B | {"type": "Point", "coordinates": [29.598125000000017, 46.432298872867094]} | 0.99181 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-068 | 관목 개체 / P2_R03-068 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-068 | B | {"type": "Point", "coordinates": [30.44812500000002, 46.432298872867094]} | 0.97906 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-069 | 관목 개체 / P2_R03-069 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-069 | B | {"type": "Point", "coordinates": [31.29812500000002, 46.432298872867094]} | 0.96631 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-070 | 관목 개체 / P2_R03-070 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-070 | B | {"type": "Point", "coordinates": [32.14812500000002, 46.432298872867094]} | 0.95356 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-071 | 관목 개체 / P2_R03-071 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-071 | B | {"type": "Point", "coordinates": [32.99812500000002, 46.432298872867094]} | 0.94081 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-072 | 관목 개체 / P2_R03-072 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-072 | A | {"type": "Point", "coordinates": [7.923125, 47.168420466083866]} | 1.33018 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-073 | 관목 개체 / P2_R03-073 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-073 | A | {"type": "Point", "coordinates": [8.773125, 47.168420466083866]} | 1.31743 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-074 | 관목 개체 / P2_R03-074 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-074 | A | {"type": "Point", "coordinates": [18.123125, 47.168420466083866]} | 1.17718 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-075 | 관목 개체 / P2_R03-075 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-075 | A | {"type": "Point", "coordinates": [18.973125000000003, 47.168420466083866]} | 1.16443 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-076 | 관목 개체 / P2_R03-076 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-076 | A | {"type": "Point", "coordinates": [19.823125000000005, 47.168420466083866]} | 1.15168 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs

# IfcGeographicElement: 영산홍 H0.6 X W0.8 (159)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 영산홍; NurserySpecification: H0.6 X W0.8
LCS_Provenance - Kind: shrub_plant; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Height_m: 0.6; CrownWidth_m: 0.8; CenterSpacing_m: 0.85; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; Quantity: 1; GeometryBasis: Nursery H/W envelope; not mature crown
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 영산홍; NurseryOrFacilitySpecification: H0.6 X W0.8; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_Y01-001 | 관목 개체 / P2_Y01-001 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-001 | C | {"type": "Point", "coordinates": [8.945272479564032, 3.166121593216773]} | 0.522811 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-002 | 관목 개체 / P2_Y01-002 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-002 | C | {"type": "Point", "coordinates": [9.795272479564032, 3.166121593216773]} | 0.510061 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-003 | 관목 개체 / P2_Y01-003 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-003 | C | {"type": "Point", "coordinates": [10.645272479564031, 3.166121593216773]} | 0.497311 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-004 | 관목 개체 / P2_Y01-004 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-004 | C | {"type": "Point", "coordinates": [11.495272479564031, 3.166121593216773]} | 0.484561 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-005 | 관목 개체 / P2_Y01-005 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-005 | C | {"type": "Point", "coordinates": [12.34527247956403, 3.166121593216773]} | 0.471811 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-006 | 관목 개체 / P2_Y01-006 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-006 | C | {"type": "Point", "coordinates": [13.19527247956403, 3.166121593216773]} | 0.459061 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-007 | 관목 개체 / P2_Y01-007 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-007 | C | {"type": "Point", "coordinates": [14.04527247956403, 3.166121593216773]} | 0.446311 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-008 | 관목 개체 / P2_Y01-008 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-008 | C | {"type": "Point", "coordinates": [14.89527247956403, 3.166121593216773]} | 0.433561 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-009 | 관목 개체 / P2_Y01-009 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-009 | C | {"type": "Point", "coordinates": [1.720272479564033, 3.902243186433546]} | 0.644436 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-010 | 관목 개체 / P2_Y01-010 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-010 | C | {"type": "Point", "coordinates": [2.570272479564033, 3.902243186433546]} | 0.631686 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-011 | 관목 개체 / P2_Y01-011 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-011 | C | {"type": "Point", "coordinates": [3.420272479564033, 3.902243186433546]} | 0.618936 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-012 | 관목 개체 / P2_Y01-012 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-012 | C | {"type": "Point", "coordinates": [4.270272479564033, 3.902243186433546]} | 0.606186 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-013 | 관목 개체 / P2_Y01-013 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-013 | C | {"type": "Point", "coordinates": [5.120272479564033, 3.902243186433546]} | 0.593436 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-014 | 관목 개체 / P2_Y01-014 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-014 | C | {"type": "Point", "coordinates": [5.9702724795640325, 3.902243186433546]} | 0.580686 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-015 | 관목 개체 / P2_Y01-015 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-015 | C | {"type": "Point", "coordinates": [7.670272479564032, 3.902243186433546]} | 0.555186 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-016 | 관목 개체 / P2_Y01-016 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-016 | C | {"type": "Point", "coordinates": [8.520272479564031, 3.902243186433546]} | 0.542436 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-017 | 관목 개체 / P2_Y01-017 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-017 | C | {"type": "Point", "coordinates": [9.370272479564031, 3.902243186433546]} | 0.529686 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-018 | 관목 개체 / P2_Y01-018 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-018 | C | {"type": "Point", "coordinates": [10.22027247956403, 3.902243186433546]} | 0.516936 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-019 | 관목 개체 / P2_Y01-019 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-019 | C | {"type": "Point", "coordinates": [11.07027247956403, 3.902243186433546]} | 0.504186 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-020 | 관목 개체 / P2_Y01-020 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-020 | C | {"type": "Point", "coordinates": [11.92027247956403, 3.902243186433546]} | 0.491436 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-021 | 관목 개체 / P2_Y01-021 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-021 | C | {"type": "Point", "coordinates": [12.77027247956403, 3.902243186433546]} | 0.478686 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-022 | 관목 개체 / P2_Y01-022 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-022 | C | {"type": "Point", "coordinates": [13.62027247956403, 3.902243186433546]} | 0.465936 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-023 | 관목 개체 / P2_Y01-023 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-023 | C | {"type": "Point", "coordinates": [14.470272479564029, 3.902243186433546]} | 0.453186 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-024 | 관목 개체 / P2_Y01-024 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-024 | C | {"type": "Point", "coordinates": [2.995272479564033, 4.638364779650319]} | 0.638561 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-025 | 관목 개체 / P2_Y01-025 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-025 | C | {"type": "Point", "coordinates": [3.845272479564033, 4.638364779650319]} | 0.625811 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-026 | 관목 개체 / P2_Y01-026 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-026 | C | {"type": "Point", "coordinates": [4.695272479564033, 4.638364779650319]} | 0.613061 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-027 | 관목 개체 / P2_Y01-027 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-027 | C | {"type": "Point", "coordinates": [5.545272479564033, 4.638364779650319]} | 0.600311 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y01-028 | 관목 개체 / P2_Y01-028 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y01-028 | C | {"type": "Point", "coordinates": [8.945272479564032, 4.638364779650319]} | 0.549311 | Y01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y02-001 | 관목 개체 / P2_Y02-001 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-001 | D | {"type": "Point", "coordinates": [29.34500000000001, 3.566121593216773]} | 0.224015 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-002 | 관목 개체 / P2_Y02-002 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-002 | D | {"type": "Point", "coordinates": [30.19500000000001, 3.566121593216773]} | 0.211265 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-003 | 관목 개체 / P2_Y02-003 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-003 | D | {"type": "Point", "coordinates": [31.045000000000012, 3.566121593216773]} | 0.198515 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-004 | 관목 개체 / P2_Y02-004 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-004 | D | {"type": "Point", "coordinates": [31.895000000000014, 3.566121593216773]} | 0.185765 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-005 | 관목 개체 / P2_Y02-005 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-005 | D | {"type": "Point", "coordinates": [32.74500000000001, 3.566121593216773]} | 0.173015 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-006 | 관목 개체 / P2_Y02-006 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-006 | D | {"type": "Point", "coordinates": [33.59500000000001, 3.566121593216773]} | 0.160265 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-007 | 관목 개체 / P2_Y02-007 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-007 | D | {"type": "Point", "coordinates": [36.14500000000002, 3.566121593216773]} | 0.122015 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-008 | 관목 개체 / P2_Y02-008 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-008 | D | {"type": "Point", "coordinates": [26.370000000000005, 4.302243186433546]} | 0.28189 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-009 | 관목 개체 / P2_Y02-009 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-009 | D | {"type": "Point", "coordinates": [27.220000000000006, 4.302243186433546]} | 0.26914 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-010 | 관목 개체 / P2_Y02-010 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-010 | D | {"type": "Point", "coordinates": [28.070000000000007, 4.302243186433546]} | 0.25639 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-011 | 관목 개체 / P2_Y02-011 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-011 | D | {"type": "Point", "coordinates": [28.92000000000001, 4.302243186433546]} | 0.24364 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-012 | 관목 개체 / P2_Y02-012 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-012 | D | {"type": "Point", "coordinates": [29.77000000000001, 4.302243186433546]} | 0.23089 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-013 | 관목 개체 / P2_Y02-013 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-013 | D | {"type": "Point", "coordinates": [30.62000000000001, 4.302243186433546]} | 0.21814 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-014 | 관목 개체 / P2_Y02-014 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-014 | D | {"type": "Point", "coordinates": [31.470000000000013, 4.302243186433546]} | 0.20539 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-015 | 관목 개체 / P2_Y02-015 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-015 | D | {"type": "Point", "coordinates": [32.320000000000014, 4.302243186433546]} | 0.19264 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-016 | 관목 개체 / P2_Y02-016 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-016 | D | {"type": "Point", "coordinates": [33.170000000000016, 4.302243186433546]} | 0.17989 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-017 | 관목 개체 / P2_Y02-017 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-017 | D | {"type": "Point", "coordinates": [36.57000000000002, 4.302243186433546]} | 0.12889 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-018 | 관목 개체 / P2_Y02-018 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-018 | D | {"type": "Point", "coordinates": [37.42000000000002, 4.302243186433546]} | 0.11614 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-019 | 관목 개체 / P2_Y02-019 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-019 | D | {"type": "Point", "coordinates": [38.270000000000024, 4.302243186433546]} | 0.10339 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-020 | 관목 개체 / P2_Y02-020 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-020 | D | {"type": "Point", "coordinates": [26.795000000000005, 5.038364779650319]} | 0.288766 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-021 | 관목 개체 / P2_Y02-021 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-021 | D | {"type": "Point", "coordinates": [27.645000000000007, 5.038364779650319]} | 0.276016 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-022 | 관목 개체 / P2_Y02-022 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-022 | D | {"type": "Point", "coordinates": [28.495000000000008, 5.038364779650319]} | 0.263266 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-023 | 관목 개체 / P2_Y02-023 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-023 | D | {"type": "Point", "coordinates": [29.34500000000001, 5.038364779650319]} | 0.250516 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-024 | 관목 개체 / P2_Y02-024 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-024 | D | {"type": "Point", "coordinates": [32.74500000000001, 5.038364779650319]} | 0.199516 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-025 | 관목 개체 / P2_Y02-025 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-025 | D | {"type": "Point", "coordinates": [33.59500000000001, 5.038364779650319]} | 0.186766 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-026 | 관목 개체 / P2_Y02-026 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-026 | D | {"type": "Point", "coordinates": [36.14500000000002, 5.038364779650319]} | 0.148516 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-027 | 관목 개체 / P2_Y02-027 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-027 | D | {"type": "Point", "coordinates": [36.99500000000002, 5.038364779650319]} | 0.135766 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-028 | 관목 개체 / P2_Y02-028 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-028 | D | {"type": "Point", "coordinates": [37.84500000000002, 5.038364779650319]} | 0.123016 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-029 | 관목 개체 / P2_Y02-029 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-029 | D | {"type": "Point", "coordinates": [34.87000000000002, 5.774486372867091]} | 0.180891 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-030 | 관목 개체 / P2_Y02-030 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-030 | D | {"type": "Point", "coordinates": [35.72000000000002, 5.774486372867091]} | 0.168141 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-031 | 관목 개체 / P2_Y02-031 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-031 | D | {"type": "Point", "coordinates": [36.57000000000002, 5.774486372867091]} | 0.155391 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y02-032 | 관목 개체 / P2_Y02-032 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y02-032 | D | {"type": "Point", "coordinates": [37.42000000000002, 5.774486372867091]} | 0.142641 | Y02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y03-001 | 관목 개체 / P2_Y03-001 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-001 | C | {"type": "Point", "coordinates": [4.051637787390378, 13.841121593216773]} | 0.788366 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-002 | 관목 개체 / P2_Y03-002 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-002 | C | {"type": "Point", "coordinates": [4.901637787390378, 13.841121593216773]} | 0.775616 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-003 | 관목 개체 / P2_Y03-003 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-003 | C | {"type": "Point", "coordinates": [4.476637787390378, 14.577243186433545]} | 0.795241 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-004 | 관목 개체 / P2_Y03-004 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-004 | C | {"type": "Point", "coordinates": [5.326637787390378, 14.577243186433545]} | 0.782491 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-005 | 관목 개체 / P2_Y03-005 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-005 | C | {"type": "Point", "coordinates": [4.051637787390378, 15.31336477965032]} | 0.814866 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-006 | 관목 개체 / P2_Y03-006 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-006 | C | {"type": "Point", "coordinates": [4.901637787390378, 15.31336477965032]} | 0.802116 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-007 | 관목 개체 / P2_Y03-007 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-007 | C | {"type": "Point", "coordinates": [5.7516377873903775, 15.31336477965032]} | 0.789366 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-008 | 관목 개체 / P2_Y03-008 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-008 | C | {"type": "Point", "coordinates": [4.476637787390378, 16.049486372867094]} | 0.821741 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-009 | 관목 개체 / P2_Y03-009 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-009 | C | {"type": "Point", "coordinates": [5.326637787390378, 16.049486372867094]} | 0.808991 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-010 | 관목 개체 / P2_Y03-010 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-010 | C | {"type": "Point", "coordinates": [6.176637787390377, 16.049486372867094]} | 0.796241 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-011 | 관목 개체 / P2_Y03-011 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-011 | C | {"type": "Point", "coordinates": [4.901637787390378, 16.785607966083866]} | 0.828616 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-012 | 관목 개체 / P2_Y03-012 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-012 | C | {"type": "Point", "coordinates": [5.7516377873903775, 16.785607966083866]} | 0.815866 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-013 | 관목 개체 / P2_Y03-013 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-013 | C | {"type": "Point", "coordinates": [6.601637787390377, 16.785607966083866]} | 0.803116 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-014 | 관목 개체 / P2_Y03-014 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-014 | C | {"type": "Point", "coordinates": [5.326637787390378, 17.52172955930064]} | 0.835492 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-015 | 관목 개체 / P2_Y03-015 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-015 | C | {"type": "Point", "coordinates": [6.176637787390377, 17.52172955930064]} | 0.822742 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-016 | 관목 개체 / P2_Y03-016 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-016 | C | {"type": "Point", "coordinates": [4.901637787390378, 18.25785115251741]} | 0.855117 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-017 | 관목 개체 / P2_Y03-017 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-017 | C | {"type": "Point", "coordinates": [5.7516377873903775, 18.25785115251741]} | 0.842367 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-018 | 관목 개체 / P2_Y03-018 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-018 | C | {"type": "Point", "coordinates": [6.601637787390377, 18.25785115251741]} | 0.829617 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-019 | 관목 개체 / P2_Y03-019 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-019 | C | {"type": "Point", "coordinates": [5.326637787390378, 18.993972745734183]} | 0.861992 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-020 | 관목 개체 / P2_Y03-020 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-020 | C | {"type": "Point", "coordinates": [6.176637787390377, 18.993972745734183]} | 0.849242 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-021 | 관목 개체 / P2_Y03-021 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-021 | C | {"type": "Point", "coordinates": [4.901637787390378, 19.730094338950956]} | 0.881617 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-022 | 관목 개체 / P2_Y03-022 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-022 | C | {"type": "Point", "coordinates": [5.7516377873903775, 19.730094338950956]} | 0.868867 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-023 | 관목 개체 / P2_Y03-023 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-023 | C | {"type": "Point", "coordinates": [4.051637787390378, 24.146823898251593]} | 0.973868 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-024 | 관목 개체 / P2_Y03-024 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-024 | C | {"type": "Point", "coordinates": [5.7516377873903775, 24.146823898251593]} | 0.948368 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y03-025 | 관목 개체 / P2_Y03-025 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_Y03-025 | C | {"type": "Point", "coordinates": [4.476637787390378, 24.882945491468366]} | 0.980743 | Y03 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_Y04-001 | 관목 개체 / P2_Y04-001 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-001 | A | {"type": "Point", "coordinates": [5.009287829733135, 32.962996593216765]} | 1.11819 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-002 | 관목 개체 / P2_Y04-002 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-002 | A | {"type": "Point", "coordinates": [5.434287829733135, 33.69911818643354]} | 1.12507 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-003 | 관목 개체 / P2_Y04-003 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-003 | A | {"type": "Point", "coordinates": [5.009287829733135, 34.43523977965031]} | 1.14469 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-004 | 관목 개체 / P2_Y04-004 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-004 | A | {"type": "Point", "coordinates": [5.859287829733135, 34.43523977965031]} | 1.13194 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-005 | 관목 개체 / P2_Y04-005 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-005 | A | {"type": "Point", "coordinates": [4.584287829733135, 35.17136137286708]} | 1.16432 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-006 | 관목 개체 / P2_Y04-006 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-006 | A | {"type": "Point", "coordinates": [5.434287829733135, 35.17136137286708]} | 1.15157 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-007 | 관목 개체 / P2_Y04-007 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-007 | A | {"type": "Point", "coordinates": [6.284287829733135, 35.17136137286708]} | 1.13882 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-008 | 관목 개체 / P2_Y04-008 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-008 | A | {"type": "Point", "coordinates": [5.009287829733135, 35.907482966083855]} | 1.1712 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-009 | 관목 개체 / P2_Y04-009 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-009 | A | {"type": "Point", "coordinates": [5.859287829733135, 35.907482966083855]} | 1.15845 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-010 | 관목 개체 / P2_Y04-010 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-010 | A | {"type": "Point", "coordinates": [6.709287829733134, 35.907482966083855]} | 1.1457 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-011 | 관목 개체 / P2_Y04-011 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-011 | A | {"type": "Point", "coordinates": [4.584287829733135, 36.64360455930063]} | 1.19082 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-012 | 관목 개체 / P2_Y04-012 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-012 | A | {"type": "Point", "coordinates": [5.434287829733135, 36.64360455930063]} | 1.17807 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-013 | 관목 개체 / P2_Y04-013 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-013 | A | {"type": "Point", "coordinates": [6.284287829733135, 36.64360455930063]} | 1.16532 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-014 | 관목 개체 / P2_Y04-014 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-014 | A | {"type": "Point", "coordinates": [4.1592878297331355, 37.37972615251741]} | 1.21045 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-015 | 관목 개체 / P2_Y04-015 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-015 | A | {"type": "Point", "coordinates": [5.009287829733135, 37.37972615251741]} | 1.1977 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-016 | 관목 개체 / P2_Y04-016 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-016 | A | {"type": "Point", "coordinates": [5.859287829733135, 37.37972615251741]} | 1.18495 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-017 | 관목 개체 / P2_Y04-017 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-017 | A | {"type": "Point", "coordinates": [4.584287829733135, 38.11584774573417]} | 1.21732 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-018 | 관목 개체 / P2_Y04-018 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-018 | A | {"type": "Point", "coordinates": [5.434287829733135, 38.11584774573417]} | 1.20457 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-019 | 관목 개체 / P2_Y04-019 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-019 | A | {"type": "Point", "coordinates": [6.284287829733135, 38.11584774573417]} | 1.19182 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-020 | 관목 개체 / P2_Y04-020 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-020 | A | {"type": "Point", "coordinates": [5.009287829733135, 38.85196933895095]} | 1.2242 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-021 | 관목 개체 / P2_Y04-021 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-021 | A | {"type": "Point", "coordinates": [5.859287829733135, 38.85196933895095]} | 1.21145 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-022 | 관목 개체 / P2_Y04-022 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-022 | A | {"type": "Point", "coordinates": [5.434287829733135, 39.588090932167724]} | 1.23107 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-023 | 관목 개체 / P2_Y04-023 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-023 | A | {"type": "Point", "coordinates": [6.284287829733135, 39.588090932167724]} | 1.21832 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-024 | 관목 개체 / P2_Y04-024 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-024 | A | {"type": "Point", "coordinates": [5.859287829733135, 40.324212525384496]} | 1.23795 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-025 | 관목 개체 / P2_Y04-025 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-025 | A | {"type": "Point", "coordinates": [5.434287829733135, 41.06033411860127]} | 1.25757 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y04-026 | 관목 개체 / P2_Y04-026 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_Y04-026 | A | {"type": "Point", "coordinates": [5.009287829733135, 41.79645571181804]} | 1.2772 | Y04 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_Y05-001 | 관목 개체 / P2_Y05-001 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y05-001 | D | {"type": "Point", "coordinates": [34.16375, 24.853621593216776]} | 0.534909 | Y05 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y05-002 | 관목 개체 / P2_Y05-002 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y05-002 | D | {"type": "Point", "coordinates": [35.01375, 24.853621593216776]} | 0.522159 | Y05 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y05-003 | 관목 개체 / P2_Y05-003 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_Y05-003 | D | {"type": "Point", "coordinates": [35.86375, 24.853621593216776]} | 0.509409 | Y05 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_Y05-004 | 관목 개체 / P2_Y05-004 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-004 | B | {"type": "Point", "coordinates": [33.73875, 25.589743186433548]} | 0.554534 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-005 | 관목 개체 / P2_Y05-005 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-005 | B | {"type": "Point", "coordinates": [34.588750000000005, 25.589743186433548]} | 0.541784 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-006 | 관목 개체 / P2_Y05-006 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-006 | B | {"type": "Point", "coordinates": [35.438750000000006, 25.589743186433548]} | 0.529034 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-007 | 관목 개체 / P2_Y05-007 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-007 | B | {"type": "Point", "coordinates": [34.16375, 26.32586477965032]} | 0.561409 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-008 | 관목 개체 / P2_Y05-008 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-008 | B | {"type": "Point", "coordinates": [35.01375, 26.32586477965032]} | 0.548659 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-009 | 관목 개체 / P2_Y05-009 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-009 | B | {"type": "Point", "coordinates": [35.86375, 26.32586477965032]} | 0.535909 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-010 | 관목 개체 / P2_Y05-010 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-010 | B | {"type": "Point", "coordinates": [35.438750000000006, 27.061986372867096]} | 0.555535 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-011 | 관목 개체 / P2_Y05-011 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-011 | B | {"type": "Point", "coordinates": [33.73875, 31.47871593216773]} | 0.660536 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-012 | 관목 개체 / P2_Y05-012 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-012 | B | {"type": "Point", "coordinates": [34.588750000000005, 31.47871593216773]} | 0.647786 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-013 | 관목 개체 / P2_Y05-013 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-013 | B | {"type": "Point", "coordinates": [35.438750000000006, 31.47871593216773]} | 0.635036 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-014 | 관목 개체 / P2_Y05-014 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-014 | B | {"type": "Point", "coordinates": [34.16375, 32.2148375253845]} | 0.667411 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-015 | 관목 개체 / P2_Y05-015 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-015 | B | {"type": "Point", "coordinates": [35.01375, 32.2148375253845]} | 0.654661 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-016 | 관목 개체 / P2_Y05-016 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-016 | B | {"type": "Point", "coordinates": [33.73875, 32.950959118601276]} | 0.687036 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-017 | 관목 개체 / P2_Y05-017 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-017 | B | {"type": "Point", "coordinates": [34.588750000000005, 32.950959118601276]} | 0.674286 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-018 | 관목 개체 / P2_Y05-018 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-018 | B | {"type": "Point", "coordinates": [35.438750000000006, 32.950959118601276]} | 0.661536 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-019 | 관목 개체 / P2_Y05-019 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-019 | B | {"type": "Point", "coordinates": [34.16375, 33.68708071181805]} | 0.693911 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-020 | 관목 개체 / P2_Y05-020 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-020 | B | {"type": "Point", "coordinates": [35.01375, 33.68708071181805]} | 0.681161 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-021 | 관목 개체 / P2_Y05-021 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-021 | B | {"type": "Point", "coordinates": [35.86375, 33.68708071181805]} | 0.668411 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-022 | 관목 개체 / P2_Y05-022 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-022 | B | {"type": "Point", "coordinates": [33.73875, 34.42320230503482]} | 0.713536 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-023 | 관목 개체 / P2_Y05-023 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-023 | B | {"type": "Point", "coordinates": [34.588750000000005, 34.42320230503482]} | 0.700786 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-024 | 관목 개체 / P2_Y05-024 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-024 | B | {"type": "Point", "coordinates": [35.438750000000006, 34.42320230503482]} | 0.688036 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-025 | 관목 개체 / P2_Y05-025 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-025 | B | {"type": "Point", "coordinates": [36.28875000000001, 34.42320230503482]} | 0.675286 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-026 | 관목 개체 / P2_Y05-026 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-026 | B | {"type": "Point", "coordinates": [33.31375, 35.1593238982516]} | 0.733162 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-027 | 관목 개체 / P2_Y05-027 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-027 | B | {"type": "Point", "coordinates": [34.16375, 35.1593238982516]} | 0.720412 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-028 | 관목 개체 / P2_Y05-028 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-028 | B | {"type": "Point", "coordinates": [35.01375, 35.1593238982516]} | 0.707662 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-029 | 관목 개체 / P2_Y05-029 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-029 | B | {"type": "Point", "coordinates": [35.86375, 35.1593238982516]} | 0.694912 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-030 | 관목 개체 / P2_Y05-030 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-030 | B | {"type": "Point", "coordinates": [33.73875, 35.895445491468365]} | 0.740037 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-031 | 관목 개체 / P2_Y05-031 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-031 | B | {"type": "Point", "coordinates": [34.588750000000005, 35.895445491468365]} | 0.727287 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-032 | 관목 개체 / P2_Y05-032 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-032 | B | {"type": "Point", "coordinates": [35.438750000000006, 35.895445491468365]} | 0.714537 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-033 | 관목 개체 / P2_Y05-033 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-033 | B | {"type": "Point", "coordinates": [33.31375, 36.631567084685145]} | 0.759662 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-034 | 관목 개체 / P2_Y05-034 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-034 | B | {"type": "Point", "coordinates": [34.16375, 36.631567084685145]} | 0.746912 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-035 | 관목 개체 / P2_Y05-035 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-035 | B | {"type": "Point", "coordinates": [35.01375, 36.631567084685145]} | 0.734162 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-036 | 관목 개체 / P2_Y05-036 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-036 | B | {"type": "Point", "coordinates": [35.86375, 36.631567084685145]} | 0.721412 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-037 | 관목 개체 / P2_Y05-037 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-037 | B | {"type": "Point", "coordinates": [33.73875, 37.36768867790191]} | 0.766537 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-038 | 관목 개체 / P2_Y05-038 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-038 | B | {"type": "Point", "coordinates": [34.588750000000005, 37.36768867790191]} | 0.753787 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-039 | 관목 개체 / P2_Y05-039 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-039 | B | {"type": "Point", "coordinates": [35.438750000000006, 37.36768867790191]} | 0.741037 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-040 | 관목 개체 / P2_Y05-040 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-040 | B | {"type": "Point", "coordinates": [33.31375, 38.10381027111869]} | 0.786162 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-041 | 관목 개체 / P2_Y05-041 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-041 | B | {"type": "Point", "coordinates": [34.16375, 38.10381027111869]} | 0.773412 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-042 | 관목 개체 / P2_Y05-042 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-042 | B | {"type": "Point", "coordinates": [35.01375, 38.10381027111869]} | 0.760662 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-043 | 관목 개체 / P2_Y05-043 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-043 | B | {"type": "Point", "coordinates": [33.73875, 38.83993186433546]} | 0.793038 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-044 | 관목 개체 / P2_Y05-044 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-044 | B | {"type": "Point", "coordinates": [34.588750000000005, 38.83993186433546]} | 0.780288 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-045 | 관목 개체 / P2_Y05-045 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-045 | B | {"type": "Point", "coordinates": [35.438750000000006, 38.83993186433546]} | 0.767538 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-046 | 관목 개체 / P2_Y05-046 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-046 | B | {"type": "Point", "coordinates": [34.16375, 39.576053457552234]} | 0.799913 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-047 | 관목 개체 / P2_Y05-047 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-047 | B | {"type": "Point", "coordinates": [35.01375, 39.576053457552234]} | 0.787163 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_Y05-048 | 관목 개체 / P2_Y05-048 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_Y05-048 | B | {"type": "Point", "coordinates": [35.86375, 39.576053457552234]} | 0.774413 | Y05 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs

# IfcGeographicElement: 이팝나무 H4.0 X R15 (7)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 이팝나무; NurserySpecification: H4.0 X R15; CrownWidthBasis: DISPLAY_ASSUMPTION
LCS_Provenance - Kind: new_tree; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; PlantingRevision: P2; Height_m: 4; CrownWidth_m: 2.5; RootCollarDiameter_cm: 15; StemVisualizationDiameter_m: 0.15; StemDiameterBasis: Catalog R represented by a simple cylinder; CrownBaseDisplay_m: 1.7; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; TreeGeometry: Planting-stock envelope; species-specific source IFC geometry not copied
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 이팝나무; NurseryOrFacilitySpecification: H4.0 X R15; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_I01 | 이팝나무 / H4.0 X R15 / P2_I01 | PK.50.30.C 교목 식재(구덩이 포함) / C구역 (교목 식재(구덩이 포함)) | P2_I01 | C | {"type": "Point", "coordinates": [5.0, 12.0]} | 0.741 | PK.50.30.C | PK.50.30.C;PK.70.10.C | C_check;C_trees
P2_I02 | 이팝나무 / H4.0 X R15 / P2_I02 | PK.50.30.D 교목 식재(구덩이 포함) / D구역 (교목 식재(구덩이 포함)) | P2_I02 | D | {"type": "Point", "coordinates": [25.0, 5.0]} | 0.315 | PK.50.30.D | PK.50.30.D;PK.70.10.D | D_check;D_trees
P2_I03 | 이팝나무 / H4.0 X R15 / P2_I03 | PK.50.30.D 교목 식재(구덩이 포함) / D구역 (교목 식재(구덩이 포함)) | P2_I03 | D | {"type": "Point", "coordinates": [35.0, 4.5]} | 0.156 | PK.50.30.D | PK.50.30.D;PK.70.10.D | D_check;D_trees
P2_I04 | 이팝나무 / H4.0 X R15 / P2_I04 | PK.50.30.A 교목 식재(구덩이 포함) / A구역 (교목 식재(구덩이 포함)) | P2_I04 | A | {"type": "Point", "coordinates": [18.5, 46.0]} | 1.1505 | PK.50.30.A | PK.50.30.A;PK.70.10.A | A_check;A_trees
P2_I05 | 이팝나무 / H4.0 X R15 / P2_I05 | PK.50.30.B 교목 식재(구덩이 포함) / B구역 (교목 식재(구덩이 포함)) | P2_I05 | B | {"type": "Point", "coordinates": [26.5, 42.5]} | 0.9675 | PK.50.30.B | PK.50.30.B;PK.70.10.B | B_check;B_trees
P2_I06 | 이팝나무 / H4.0 X R15 / P2_I06 | PK.50.30.D 교목 식재(구덩이 포함) / D구역 (교목 식재(구덩이 포함)) | P2_I06 | D | {"type": "Point", "coordinates": [36.5, 23.5]} | 0.4755 | PK.50.30.D | PK.50.30.D;PK.70.10.D | D_check;D_trees
P2_I07 | 이팝나무 / H4.0 X R15 / P2_I07 | PK.50.30.A 교목 식재(구덩이 포함) / A구역 (교목 식재(구덩이 포함)) | P2_I07 | A | {"type": "Point", "coordinates": [3.2, 26.5]} | 1.029 | PK.50.30.A | PK.50.30.A;PK.70.10.A | A_check;A_trees

# IfcGeographicElement: 조팝나무 H1.0 X W0.5 (177)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 조팝나무; NurserySpecification: H1.0 X W0.5
LCS_Provenance - Kind: shrub_plant; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Height_m: 1; CrownWidth_m: 0.5; CenterSpacing_m: 0.75; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; Quantity: 1; GeometryBasis: Nursery H/W envelope; not mature crown
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 조팝나무; NurseryOrFacilitySpecification: H1.0 X W0.5; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_S01-001 | 관목 개체 / P2_S01-001 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_S01-001 | D | {"type": "Point", "coordinates": [37.15518824728638, 24.780938611197953]} | 0.488729 | S01 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_S01-002 | 관목 개체 / P2_S01-002 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_S01-002 | D | {"type": "Point", "coordinates": [37.90518824728638, 24.780938611197953]} | 0.477479 | S01 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_S01-003 | 관목 개체 / P2_S01-003 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-003 | B | {"type": "Point", "coordinates": [36.78018824728638, 25.430457664036282]} | 0.506045 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-004 | 관목 개체 / P2_S01-004 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-004 | B | {"type": "Point", "coordinates": [37.53018824728638, 25.430457664036282]} | 0.494795 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-005 | 관목 개체 / P2_S01-005 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-005 | B | {"type": "Point", "coordinates": [38.28018824728638, 25.430457664036282]} | 0.483545 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-006 | 관목 개체 / P2_S01-006 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-006 | B | {"type": "Point", "coordinates": [37.15518824728638, 26.07997671687461]} | 0.512112 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-007 | 관목 개체 / P2_S01-007 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-007 | B | {"type": "Point", "coordinates": [37.90518824728638, 26.07997671687461]} | 0.500862 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-008 | 관목 개체 / P2_S01-008 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-008 | B | {"type": "Point", "coordinates": [38.65518824728638, 26.07997671687461]} | 0.489612 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-009 | 관목 개체 / P2_S01-009 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-009 | B | {"type": "Point", "coordinates": [36.78018824728638, 26.72949576971294]} | 0.529428 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-010 | 관목 개체 / P2_S01-010 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-010 | B | {"type": "Point", "coordinates": [37.53018824728638, 26.72949576971294]} | 0.518178 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-011 | 관목 개체 / P2_S01-011 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-011 | B | {"type": "Point", "coordinates": [38.28018824728638, 26.72949576971294]} | 0.506928 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-012 | 관목 개체 / P2_S01-012 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-012 | B | {"type": "Point", "coordinates": [39.03018824728638, 26.72949576971294]} | 0.495678 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-013 | 관목 개체 / P2_S01-013 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-013 | B | {"type": "Point", "coordinates": [36.40518824728638, 27.37901482255127]} | 0.546744 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-014 | 관목 개체 / P2_S01-014 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-014 | B | {"type": "Point", "coordinates": [37.15518824728638, 27.37901482255127]} | 0.535494 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-015 | 관목 개체 / P2_S01-015 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-015 | B | {"type": "Point", "coordinates": [37.90518824728638, 27.37901482255127]} | 0.524244 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-016 | 관목 개체 / P2_S01-016 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-016 | B | {"type": "Point", "coordinates": [38.65518824728638, 27.37901482255127]} | 0.512994 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-017 | 관목 개체 / P2_S01-017 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-017 | B | {"type": "Point", "coordinates": [36.03018824728638, 28.0285338753896]} | 0.564061 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-018 | 관목 개체 / P2_S01-018 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-018 | B | {"type": "Point", "coordinates": [36.78018824728638, 28.0285338753896]} | 0.552811 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-019 | 관목 개체 / P2_S01-019 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-019 | B | {"type": "Point", "coordinates": [37.53018824728638, 28.0285338753896]} | 0.541561 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-020 | 관목 개체 / P2_S01-020 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-020 | B | {"type": "Point", "coordinates": [38.28018824728638, 28.0285338753896]} | 0.530311 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
