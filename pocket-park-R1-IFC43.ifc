Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 9

# IfcGeographicElement (13)
Name | Description | PredefinedType | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Kind | Zone | GeometryJSON | ElevationMetre | cover (m2) | TopPlane | DisplayOffset_m | DisplayLayerThickness_m | QuantityBasis | InventoryRole | PrimaryWBS | WBSCodeList | LegacyTaskIds | LinkedTaskCount | ItemName | Group | MappingNote
shrub_A | 관목·초본식재 / shrub_A | VEGETATION | PK.50.20.A 식재기반 정비 / A구역 (식재기반 정비) | shrub_A | shrub | A | {"type": "MultiPolygon", "coordinates": [[[[2.525, 25.4375], [3.0749999999999997, 25.5625], [3.5906249999999997, 25.6328125], [4.071875, 25.6484375], [4.51875, 25.609375], [4.9312499999999995, 25.515625], [5.309374999999999, 25.3671875], [5.653124999999999, 25.1640625], [5.85, 25.0], [1.6453125, 25.0], [2.0484375, 25.25], [2.525, 25.4375]]], [[[0.6437499999999999, 37.75], [0.73125, 38.625], [0.8624999999999998, 39.40625], [1.0374999999999996, 40.09375], [1.2562499999999996, 40.6875], [1.5187499999999998, 41.1875], [1.8249999999999997, 41.59375], [2.175, 41.90625], [2.5312499999999996, 42.1609375], [2.89375, 42.357812499999994], [3.2624999999999997, 42.496875], [3.6374999999999993, 42.578125], [4.018749999999999, 42.60156250000001], [4.40625, 42.5671875], [4.8, 42.475], [5.199999999999999, 42.325], [5.5562499999999995, 42.1421875], [5.8687499999999995, 41.926562499999996], [6.137499999999999, 41.678124999999994], [6.362499999999999, 41.396874999999994], [6.543749999999999, 41.082812499999996], [6.68125, 40.7359375], [6.775, 40.35625], [6.825, 39.943749999999994], [6.875, 39.534375], [6.925000000000001, 39.128125], [6.975, 38.725], [7.025, 38.325], [7.074999999999999, 37.928125], [7.125, 37.534375000000004], [7.175, 37.143750000000004], [7.225, 36.75625], [7.2515625, 36.3734375], [7.2546875, 35.9953125], [7.234375, 35.621874999999996], [7.190625000000001, 35.253125], [7.1234375000000005, 34.889062499999994], [7.0328125, 34.5296875], [6.91875, 34.175000000000004], [6.78125, 33.824999999999996], [6.615625, 33.506249999999994], [6.421874999999999, 33.21875], [6.199999999999999, 32.962500000000006], [5.949999999999999, 32.73750000000001], [5.671874999999999, 32.54375000000001], [5.365625, 32.38125], [5.03125, 32.25], [4.668749999999999, 32.150000000000006], [4.3078125, 32.065625000000004], [3.9484375, 31.996874999999996], [3.5906249999999997, 31.943749999999998], [3.234375, 31.90625], [2.8796874999999997, 31.884375000000002], [2.5265625, 31.878125000000004], [2.175, 31.887500000000003], [1.8249999999999997, 31.912499999999998], [1.5187499999999998, 32.067187499999996], [1.2562499999999996, 32.3515625], [1.0374999999999996, 32.765625], [0.8624999999999998, 33.309374999999996], [0.73125, 33.982812499999994], [0.6437499999999999, 34.7859375], [0.6, 35.71875], [0.6, 36.78125], [0.6437499999999999, 37.75]], [[3.1463177415120964, 37.73558896030242], [3.07351285524717, 37.746388545004145], [3.0, 37.75], [2.9264871447528296, 37.746388545004145], [2.8536822584879036, 37.73558896030242], [2.782286492059153, 37.71770525179916], [2.7129874257261823, 37.692909649383466], [2.6464524473805016, 37.661440948261266], [2.583322325235298, 37.62360220922691], [2.5242050368772655, 37.579757840022054], [2.4696699141100895, 37.53033008588991], [2.4202421599779473, 37.47579496312273], [2.376397790773091, 37.4166776747647], [2.338559051738734, 37.353547552619496], [2.307090350616535, 37.28701257427382], [2.2822947482008433, 37.21771350794085], [2.264411039697577, 37.1463177415121], [2.2536114549958524, 37.07351285524717], [2.25, 37.0], [2.2536114549958524, 36.92648714475283], [2.264411039697577, 36.8536822584879], [2.2822947482008433, 36.78228649205915], [2.307090350616535, 36.71298742572618], [2.338559051738734, 36.646452447380504], [2.376397790773091, 36.5833223252353], [2.4202421599779473, 36.52420503687726], [2.4696699141100895, 36.46966991411009], [2.524205036877266, 36.420242159977946], [2.5833223252352986, 36.37639779077309], [2.6464524473805016, 36.338559051738734], [2.712987425726183, 36.307090350616534], [2.7822864920591535, 36.28229474820084], [2.853682258487904, 36.26441103969758], [2.9264871447528296, 36.253611454995855], [3.0, 36.25], [3.0735128552471704, 36.253611454995855], [3.1463177415120964, 36.26441103969758], [3.2177135079408465, 36.28229474820084], [3.287012574273817, 36.307090350616534], [3.3535475526194984, 36.338559051738734], [3.416677674764702, 36.37639779077309], [3.475794963122734, 36.420242159977946], [3.5303300858899105, 36.46966991411009], [3.564287829733135, 36.5071365108006], [4.4, 34.0], [3.5642878297331357, 36.5071365108006], [3.5797578400220527, 36.52420503687726], [3.6236022092269087, 36.5833223252353], [3.661440948261266, 36.646452447380504], [3.692909649383465, 36.71298742572618], [3.7177052517991567, 36.78228649205915], [3.735588960302423, 36.8536822584879], [3.7463885450041476, 36.92648714475283], [3.75, 37.0], [3.7463885450041476, 37.07351285524717], [3.735588960302423, 37.1463177415121], [3.7177052517991567, 37.21771350794085], [3.692909649383465, 37.28701257427382], [3.661440948261266, 37.353547552619496], [3.6236022092269087, 37.4166776747647], [3.5797578400220527, 37.47579496312274], [3.5303300858899105, 37.53033008588991], [3.475794963122734, 37.579757840022054], [3.4166776747647014, 37.62360220922691], [3.3535475526194984, 37.661440948261266], [3.2870125742738177, 37.692909649383466], [3.2177135079408465, 37.71770525179916], [3.1463177415120964, 37.73558896030242]]], [[[7.875, 44.99375], [7.671875, 45.3], [7.515625, 45.62499999999999], [7.40625, 45.96875], [7.34375, 46.331250000000004], [7.328125, 46.712500000000006], [7.359375, 47.1125], [7.4375, 47.53125], [7.5625, 47.96875], [7.734375, 48.346875], [7.953125, 48.665625000000006], [8.21875, 48.925000000000004], [8.53125, 49.125], [8.890625, 49.26562499999999], [9.296875, 49.346875], [9.75, 49.36875], [10.25, 49.33125], [10.78125, 49.303125], [11.34375, 49.284375000000004], [11.9375, 49.275000000000006], [12.5625, 49.275000000000006], [13.21875, 49.284375000000004], [13.90625, 49.303125], [14.625, 49.33125], [15.375, 49.36875], [16.109375, 49.39375], [16.828125, 49.40624999999999], [17.53125, 49.40625], [18.21875, 49.393750000000004], [18.890625, 49.368750000000006], [19.546875, 49.33125], [20.0, 49.295884146341464], [20.0, 44.45190677966101], [19.671875, 44.553124999999994], [19.203125, 44.671875], [18.7265625, 44.7671875], [18.2421875, 44.8390625], [17.75, 44.8875], [17.25, 44.9125], [16.7578125, 44.91875], [16.2734375, 44.90625000000001], [15.796875, 44.875], [15.328125, 44.824999999999996], [14.8671875, 44.756249999999994], [14.4140625, 44.66875], [13.96875, 44.5625], [13.53125, 44.4375], [13.1015625, 44.3234375], [12.6796875, 44.220312500000006], [12.265625, 44.128125000000004], [11.859375, 44.046875], [11.71630486423801, 44.02162732898318], [11.692909649383465, 44.087012574273814], [11.661440948261266, 44.15354755261949], [11.62360220922691, 44.216677674764696], [11.579757840022053, 44.275794963122735], [11.530330085889911, 44.330330085889905], [11.475794963122734, 44.37975784002205], [11.416677674764701, 44.42360220922691], [11.353547552619498, 44.46144094826126], [11.287012574273817, 44.49290964938346], [11.217713507940847, 44.51770525179916], [11.146317741512096, 44.53558896030242], [11.07351285524717, 44.54638854500414], [11.0, 44.55], [10.92648714475283, 44.54638854500414], [10.853682258487904, 44.53558896030242], [10.782286492059153, 44.51770525179916], [10.712987425726181, 44.49290964938346], [10.646452447380502, 44.46144094826126], [10.583322325235299, 44.42360220922691], [10.524205036877266, 44.37975784002205], [10.469669914110089, 44.330330085889905], [10.420242159977947, 44.27579496312273], [10.37639779077309, 44.216677674764696], [10.338559051738734, 44.15354755261949], [10.307090350616535, 44.087012574273814], [10.282294748200844, 44.01771350794085], [10.264411039697578, 43.9463177415121], [10.253611454995852, 43.87351285524717], [10.25156124648129, 43.83177990220451], [9.953125, 43.834375], [9.609375, 43.878125000000004], [9.28125, 43.962500000000006], [8.96875, 44.087500000000006], [8.671875, 44.253125000000004], [8.390625, 44.459375], [8.125, 44.70625], [7.875, 44.99375]], [[19.07975784002205, 46.47579496312274], [19.03033008588991, 46.53033008588991], [18.975794963122734, 46.579757840022054], [18.916677674764703, 46.62360220922691], [18.8535475526195, 46.661440948261266], [18.787012574273817, 46.692909649383466], [18.717713507940847, 46.71770525179916], [18.646317741512096, 46.73558896030242], [18.57351285524717, 46.746388545004145], [18.5, 46.75], [18.42648714475283, 46.746388545004145], [18.353682258487904, 46.73558896030242], [18.282286492059153, 46.71770525179916], [18.212987425726183, 46.692909649383466], [18.1464524473805, 46.661440948261266], [18.083322325235297, 46.62360220922691], [18.024205036877266, 46.579757840022054], [17.96966991411009, 46.53033008588991], [17.920242159977946, 46.47579496312273], [17.87639779077309, 46.4166776747647], [17.838559051738734, 46.353547552619496], [17.807090350616534, 46.28701257427382], [17.782294748200844, 46.21771350794085], [17.764411039697578, 46.1463177415121], [17.753611454995852, 46.07351285524717], [17.75, 46.0], [17.753611454995852, 45.92648714475283], [17.764411039697578, 45.8536822584879], [17.782294748200844, 45.78228649205915], [17.807090350616534, 45.71298742572618], [17.838559051738734, 45.646452447380504], [17.87639779077309, 45.5833223252353], [17.920242159977946, 45.52420503687726], [17.96966991411009, 45.46966991411009], [18.024205036877266, 45.420242159977946], [18.083322325235297, 45.37639779077309], [18.1464524473805, 45.338559051738734], [18.212987425726183, 45.307090350616534], [18.282286492059153, 45.28229474820084], [18.353682258487904, 45.26441103969758], [18.42648714475283, 45.253611454995855], [18.5, 45.25], [18.57351285524717, 45.253611454995855], [18.646317741512096, 45.26441103969758], [18.717713507940847, 45.28229474820084], [18.787012574273817, 45.307090350616534], [18.8535475526195, 45.338559051738734], [18.916677674764703, 45.37639779077309], [18.975794963122734, 45.420242159977946], [19.03033008588991, 45.46966991411009], [19.079757840022054, 45.52420503687726], [19.12360220922691, 45.5833223252353], [19.161440948261266, 45.646452447380504], [19.192909649383466, 45.71298742572618], [19.217705251799156, 45.78228649205915], [19.235588960302422, 45.8536822584879], [19.246388545004148, 45.92648714475283], [19.25, 46.0], [19.246388545004148, 46.07351285524717], [19.235588960302422, 46.1463177415121], [19.217705251799156, 46.21771350794085], [19.192909649383466, 46.28701257427382], [19.161440948261266, 46.353547552619496], [19.12360220922691, 46.4166776747647], [19.07975784002205, 46.47579496312274]]]]} | 1.24843 | 117.639 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Planting bed area; 677 individual shrubs modelled and counted separately | SURFACE_GROUP | PK.50.20.A | PK.50.20.A;PK.70.10.A | A_check;A_soil | 2 | 관목 식재지 | 20 수목·녹지 | 군락 면적; 관목 개체 수와 중복 합산하지 않음
shrub_B | 관목·초본식재 / shrub_B | VEGETATION | PK.50.20.B 식재기반 정비 / B구역 (식재기반 정비) | shrub_B | shrub | B | {"type": "MultiPolygon", "coordinates": [[[[32.9625, 25.6875], [32.9046875, 26.09375], [32.8640625, 26.53125], [32.840625, 27.0], [32.834375, 27.5], [32.838366219240186, 27.693859220237535], [32.88981175271362, 27.64723170661521], [33.0277520922157, 27.544928178470546], [33.1750557105545, 27.456637787390378], [33.33030399336109, 27.383210818105248], [33.49200181480469, 27.325354412468634], [33.65859193647177, 27.283625759294345], [33.82847000442327, 27.258426728323656], [34.0, 27.25], [34.17152999557673, 27.258426728323656], [34.34140806352823, 27.283625759294345], [34.50799818519531, 27.325354412468634], [34.66969600663891, 27.383210818105248], [34.8249442894455, 27.456637787390378], [34.97224790778431, 27.544928178470546], [35.11018824728638, 27.64723170661521], [35.23743686707646, 27.762563132923542], [35.35276829338479, 27.88981175271362], [35.45507182152945, 28.027752092215696], [35.54336221260962, 28.175055710554503], [35.61678918189475, 28.330303993361092], [35.674645587531366, 28.49200181480469], [35.716374240705655, 28.658591936471776], [35.741573271676344, 28.82847000442327], [35.75, 29.0], [35.741573271676344, 29.17152999557673], [35.716374240705655, 29.341408063528224], [35.674645587531366, 29.50799818519531], [35.61678918189475, 29.669696006638908], [35.54336221260962, 29.824944289445497], [35.45507182152945, 29.972247907784304], [35.35276829338479, 30.11018824728638], [35.23743686707646, 30.237436867076458], [35.11018824728638, 30.35276829338479], [34.9722479077843, 30.455071821529454], [34.8249442894455, 30.543362212609622], [34.66969600663891, 30.616789181894752], [34.507998185195305, 30.674645587531366], [34.34140806352823, 30.716374240705655], [34.17152999557673, 30.741573271676344], [34.0, 30.75], [33.82847000442327, 30.741573271676344], [33.65859193647177, 30.716374240705655], [33.49200181480469, 30.674645587531366], [33.33030399336109, 30.616789181894752], [33.1750557105545, 30.543362212609622], [33.02814616947982, 30.455308022351655], [33.0546875, 31.015625], [33.065625000000004, 31.59375], [33.059375, 32.15625], [33.0359375, 32.703125], [32.995312500000004, 33.234375], [32.9375, 33.75], [32.862500000000004, 34.25], [32.803125, 34.746875], [32.759375, 35.240624999999994], [32.73125, 35.73125], [32.71875, 36.21875], [32.721875000000004, 36.703125], [32.740625, 37.184375], [32.775, 37.662499999999994], [32.824999999999996, 38.1375], [32.93124999999999, 38.578125], [33.09375, 38.98437499999999], [33.3125, 39.35624999999999], [33.587500000000006, 39.693749999999994], [33.91875, 39.996874999999996], [34.30625, 40.265625], [34.75, 40.5], [35.25, 40.699999999999996], [35.721875, 40.857812499999994], [36.165625000000006, 40.9734375], [36.58125, 41.046875], [36.96875, 41.078125], [37.328125, 41.0671875], [37.659375, 41.014062499999994], [37.962500000000006, 40.918749999999996], [38.2375, 40.78125], [38.4828125, 40.5625], [38.698437500000004, 40.262499999999996], [38.884375000000006, 39.881249999999994], [39.040625000000006, 39.41874999999999], [39.167187500000004, 38.87499999999999], [39.2640625, 38.25], [39.33125, 37.54375], [39.368750000000006, 36.756249999999994], [39.3984375, 35.9890625], [39.420312499999994, 35.2421875], [39.434374999999996, 34.515625], [39.440625000000004, 33.809375], [39.439062500000006, 33.123437499999994], [39.4296875, 32.4578125], [39.412499999999994, 31.8125], [39.3875, 31.1875], [39.36875, 30.58125], [39.356249999999996, 29.99375], [39.349999999999994, 29.424999999999997], [39.349999999999994, 28.875000000000004], [39.356249999999996, 28.343750000000004], [39.36875, 27.831250000000004], [39.3875, 27.337500000000002], [39.412499999999994, 26.862499999999997], [39.389062499999994, 26.424999999999997], [39.3171875, 26.025], [39.196875, 25.662499999999998], [39.028124999999996, 25.3375], [38.810937499999994, 25.049999999999997], [38.7578125, 25.0], [33.148054245283014, 25.0], [33.0375, 25.3125], [32.9625, 25.6875]]], [[[20.8125, 49.21875], [21.4375, 49.171875], [22.0625, 49.140625], [22.6875, 49.125], [23.3125, 49.125], [23.9375, 49.140625], [24.5625, 49.171875], [25.1875, 49.21875], [25.8125, 49.28125], [26.45, 49.334375], [27.1, 49.378125], [27.762500000000003, 49.412499999999994], [28.437499999999996, 49.43750000000001], [29.124999999999996, 49.45312500000001], [29.824999999999996, 49.45937500000001], [30.537499999999998, 49.456250000000004], [31.262499999999996, 49.443749999999994], [31.899999999999995, 49.37968749999999], [32.449999999999996, 49.264062499999994], [32.912499999999994, 49.096875], [33.287499999999994, 48.878125], [33.574999999999996, 48.607812499999994], [33.775, 48.28593749999999], [33.8875, 47.912499999999994], [33.912499999999994, 47.487500000000004], [33.8875, 47.10156250000001], [33.8125, 46.7546875], [33.6875, 46.446875], [33.5125, 46.178125], [33.287499999999994, 45.9484375], [33.0125, 45.75781249999999], [32.6875, 45.606249999999996], [32.3125, 45.493750000000006], [31.9375, 45.37031250000001], [31.5625, 45.235937500000006], [31.1875, 45.090625], [30.8125, 44.934375], [30.4375, 44.767187500000006], [30.0625, 44.58906250000001], [29.6875, 44.400000000000006], [29.3125, 44.199999999999996], [28.90625, 44.01875], [28.46875, 43.856249999999996], [28.0, 43.7125], [27.5, 43.5875], [26.96875, 43.481249999999996], [26.40625, 43.39375], [25.8125, 43.324999999999996], [25.1875, 43.275000000000006], [24.5859375, 43.25781250000001], [24.0078125, 43.27343750000001], [23.453125, 43.321875000000006], [22.921875, 43.403125], [22.4140625, 43.517187500000006], [21.9296875, 43.6640625], [21.46875, 43.84375], [21.03125, 44.05625], [20.5859375, 44.2453125], [20.1328125, 44.410937499999996], [20.0, 44.45190677966101], [20.0, 49.295884146341464], [20.1875, 49.28125], [20.8125, 49.21875]], [[23.57975784002205, 48.47579496312274], [23.53033008588991, 48.53033008588991], [23.475794963122734, 48.579757840022054], [23.416677674764703, 48.62360220922691], [23.3535475526195, 48.661440948261266], [23.287012574273817, 48.692909649383466], [23.217713507940847, 48.71770525179916], [23.146317741512096, 48.73558896030242], [23.07351285524717, 48.746388545004145], [23.0, 48.75], [22.92648714475283, 48.746388545004145], [22.853682258487904, 48.73558896030242], [22.782286492059153, 48.71770525179916], [22.712987425726183, 48.692909649383466], [22.6464524473805, 48.661440948261266], [22.583322325235297, 48.62360220922691], [22.524205036877266, 48.579757840022054], [22.46966991411009, 48.53033008588991], [22.420242159977946, 48.47579496312273], [22.37639779077309, 48.4166776747647], [22.338559051738734, 48.353547552619496], [22.307090350616534, 48.28701257427382], [22.282294748200844, 48.21771350794085], [22.264411039697578, 48.1463177415121], [22.253611454995852, 48.07351285524717], [22.25, 48.0], [22.253611454995852, 47.92648714475283], [22.264411039697578, 47.8536822584879], [22.282294748200844, 47.78228649205915], [22.307090350616534, 47.71298742572618], [22.338559051738734, 47.646452447380504], [22.37639779077309, 47.5833223252353], [22.420242159977946, 47.52420503687726], [22.46966991411009, 47.46966991411009], [22.524205036877266, 47.420242159977946], [22.583322325235297, 47.37639779077309], [22.6464524473805, 47.338559051738734], [22.712987425726183, 47.307090350616534], [22.782286492059153, 47.28229474820084], [22.853682258487904, 47.26441103969758], [22.92648714475283, 47.253611454995855], [23.0, 47.25], [23.07351285524717, 47.253611454995855], [23.146317741512096, 47.26441103969758], [23.217713507940847, 47.28229474820084], [23.287012574273817, 47.307090350616534], [23.3535475526195, 47.338559051738734], [23.416677674764703, 47.37639779077309], [23.475794963122734, 47.420242159977946], [23.53033008588991, 47.46966991411009], [23.579757840022054, 47.52420503687726], [23.62360220922691, 47.5833223252353], [23.661440948261266, 47.646452447380504], [23.692909649383466, 47.71298742572618], [23.717705251799156, 47.78228649205915], [23.735588960302422, 47.8536822584879], [23.746388545004148, 47.92648714475283], [23.75, 48.0], [23.746388545004148, 48.07351285524717], [23.735588960302422, 48.1463177415121], [23.717705251799156, 48.21771350794085], [23.692909649383466, 48.28701257427382], [23.661440948261266, 48.353547552619496], [23.62360220922691, 48.4166776747647], [23.57975784002205, 48.47579496312274]], [[28.07975784002205, 47.97579496312274], [28.03033008588991, 48.03033008588991], [27.975794963122734, 48.079757840022054], [27.916677674764703, 48.12360220922691], [27.8535475526195, 48.161440948261266], [27.787012574273817, 48.192909649383466], [27.717713507940847, 48.21770525179916], [27.646317741512096, 48.23558896030242], [27.57351285524717, 48.246388545004145], [27.5, 48.25], [27.42648714475283, 48.246388545004145], [27.353682258487904, 48.23558896030242], [27.282286492059153, 48.21770525179916], [27.212987425726183, 48.192909649383466], [27.1464524473805, 48.161440948261266], [27.083322325235297, 48.12360220922691], [27.024205036877266, 48.079757840022054], [26.96966991411009, 48.03033008588991], [26.920242159977946, 47.97579496312273], [26.87639779077309, 47.9166776747647], [26.838559051738734, 47.853547552619496], [26.807090350616534, 47.78701257427382], [26.782294748200844, 47.71771350794085], [26.764411039697578, 47.6463177415121], [26.753611454995852, 47.57351285524717], [26.75, 47.5], [26.753611454995852, 47.42648714475283], [26.764411039697578, 47.3536822584879], [26.782294748200844, 47.28228649205915], [26.807090350616534, 47.21298742572618], [26.838559051738734, 47.146452447380504], [26.87639779077309, 47.0833223252353], [26.920242159977946, 47.02420503687726], [26.96966991411009, 46.96966991411009], [27.024205036877266, 46.920242159977946], [27.083322325235297, 46.87639779077309], [27.1464524473805, 46.838559051738734], [27.212987425726183, 46.807090350616534], [27.282286492059153, 46.78229474820084], [27.353682258487904, 46.76441103969758], [27.42648714475283, 46.753611454995855], [27.5, 46.75], [27.57351285524717, 46.753611454995855], [27.646317741512096, 46.76441103969758], [27.717713507940847, 46.78229474820084], [27.787012574273817, 46.807090350616534], [27.8535475526195, 46.838559051738734], [27.916677674764703, 46.87639779077309], [27.975794963122734, 46.920242159977946], [28.03033008588991, 46.96966991411009], [28.079757840022054, 47.02420503687726], [28.12360220922691, 47.0833223252353], [28.161440948261266, 47.146452447380504], [28.192909649383466, 47.21298742572618], [28.217705251799156, 47.28228649205915], [28.235588960302422, 47.3536822584879], [28.246388545004148, 47.42648714475283], [28.25, 47.5], [28.246388545004148, 47.57351285524717], [28.235588960302422, 47.6463177415121], [28.217705251799156, 47.71771350794085], [28.192909649383466, 47.78701257427382], [28.161440948261266, 47.853547552619496], [28.12360220922691, 47.9166776747647], [28.07975784002205, 47.97579496312274]], [[32.079757840022054, 48.47579496312274], [32.03033008588991, 48.53033008588991], [31.975794963122734, 48.579757840022054], [31.916677674764703, 48.62360220922691], [31.8535475526195, 48.661440948261266], [31.787012574273817, 48.692909649383466], [31.717713507940847, 48.71770525179916], [31.646317741512096, 48.73558896030242], [31.57351285524717, 48.746388545004145], [31.5, 48.75], [31.42648714475283, 48.746388545004145], [31.353682258487904, 48.73558896030242], [31.282286492059153, 48.71770525179916], [31.212987425726183, 48.692909649383466], [31.1464524473805, 48.661440948261266], [31.083322325235297, 48.62360220922691], [31.024205036877266, 48.579757840022054], [30.96966991411009, 48.53033008588991], [30.920242159977946, 48.47579496312273], [30.87639779077309, 48.4166776747647], [30.838559051738734, 48.353547552619496], [30.807090350616534, 48.28701257427382], [30.782294748200844, 48.21771350794085], [30.764411039697578, 48.1463177415121], [30.753611454995852, 48.07351285524717], [30.75, 48.0], [30.753611454995852, 47.92648714475283], [30.764411039697578, 47.8536822584879], [30.782294748200844, 47.78228649205915], [30.807090350616534, 47.71298742572618], [30.838559051738734, 47.646452447380504], [30.87639779077309, 47.5833223252353], [30.920242159977946, 47.52420503687726], [30.96966991411009, 47.46966991411009], [31.024205036877266, 47.420242159977946], [31.083322325235297, 47.37639779077309], [31.1464524473805, 47.338559051738734], [31.212987425726183, 47.307090350616534], [31.282286492059153, 47.28229474820084], [31.353682258487904, 47.26441103969758], [31.42648714475283, 47.253611454995855], [31.5, 47.25], [31.57351285524717, 47.253611454995855], [31.646317741512096, 47.26441103969758], [31.717713507940847, 47.28229474820084], [31.787012574273817, 47.307090350616534], [31.8535475526195, 47.338559051738734], [31.916677674764703, 47.37639779077309], [31.975794963122734, 47.420242159977946], [32.03033008588991, 47.46966991411009], [32.079757840022054, 47.52420503687726], [32.12360220922691, 47.5833223252353], [32.161440948261266, 47.646452447380504], [32.192909649383466, 47.71298742572618], [32.21770525179916, 47.78228649205915], [32.23558896030242, 47.8536822584879], [32.246388545004145, 47.92648714475283], [32.25, 48.0], [32.246388545004145, 48.07351285524717], [32.23558896030242, 48.1463177415121], [32.21770525179916, 48.21771350794085], [32.192909649383466, 48.28701257427382], [32.161440948261266, 48.353547552619496], [32.12360220922691, 48.4166776747647], [32.079757840022054, 48.47579496312274]]]]} | 1.03163 | 156.7 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Planting bed area; 677 individual shrubs modelled and counted separately | SURFACE_GROUP | PK.50.20.B | PK.50.20.B;PK.70.10.B | B_check;B_soil | 2 | 관목 식재지 | 20 수목·녹지 | 군락 면적; 관목 개체 수와 중복 합산하지 않음
shrub_C | 관목·초본식재 / shrub_C | VEGETATION | PK.50.20.C 식재기반 정비 / C구역 (식재기반 정비) | shrub_C | shrub | C | {"type": "MultiPolygon", "coordinates": [[[[11.9375, 1.0484375000000001], [11.3125, 1.0281250000000002], [10.6875, 0.9968750000000001], [10.0625, 0.9546875], [9.4375, 0.9015625], [8.8125, 0.8375], [8.1875, 0.7625000000000001], [7.5546875, 0.7046875000000001], [6.9140625, 0.6640625], [6.265625, 0.640625], [5.609375, 0.6343749999999999], [4.9453125, 0.6453125], [4.2734375, 0.6734375], [3.59375, 0.71875], [2.90625, 0.78125], [2.3046875, 0.871875], [1.7890625, 0.9906250000000001], [1.359375, 1.1375000000000002], [1.015625, 1.3124999999999998], [0.7578125, 1.5156249999999998], [0.5859375, 1.7468749999999997], [0.5, 2.0062499999999996], [0.5, 2.2937499999999993], [0.5234375, 2.5781249999999996], [0.5703125, 2.8593749999999996], [0.640625, 3.1374999999999993], [0.7002724795640328, 3.312465940054496], [0.734375, 3.4124999999999996], [0.8515625, 3.6843749999999997], [0.9921875, 3.953125], [1.15625, 4.21875], [1.34375, 4.481250000000001], [1.5859375, 4.7171875000000005], [1.8828125, 4.926562500000001], [2.234375, 5.109375000000001], [2.640625, 5.265625000000001], [3.1015625, 5.395312500000001], [3.6171875, 5.4984375000000005], [4.1875, 5.575], [4.8125, 5.625], [5.4140625, 5.653124999999999], [5.9921875, 5.659374999999999], [6.546875, 5.643749999999999], [6.6095550895899, 5.639325523087771], [6.583322325235298, 5.623602209226909], [6.524205036877266, 5.579757840022053], [6.4696699141100895, 5.5303300858899105], [6.420242159977947, 5.475794963122734], [6.37639779077309, 5.416677674764702], [6.338559051738733, 5.353547552619498], [6.307090350616535, 5.287012574273818], [6.282294748200844, 5.2177135079408465], [6.264411039697578, 5.146317741512096], [6.253611454995852, 5.07351285524717], [6.25, 5.0], [6.253611454995852, 4.926487144752829], [6.264411039697578, 4.853682258487903], [6.282294748200844, 4.7822864920591535], [6.3070903506165354, 4.712987425726182], [6.338559051738734, 4.646452447380502], [6.376397790773091, 4.583322325235298], [6.420242159977947, 4.524205036877266], [6.4696699141100895, 4.4696699141100895], [6.524205036877266, 4.420242159977947], [6.583322325235298, 4.376397790773091], [6.646452447380502, 4.338559051738733], [6.712987425726182, 4.3070903506165354], [6.7822864920591535, 4.282294748200844], [6.853682258487904, 4.264411039697578], [6.926487144752829, 4.253611454995852], [7.0, 4.25], [7.073512855247171, 4.253611454995852], [7.146317741512096, 4.264411039697578], [7.2177135079408465, 4.282294748200844], [7.287012574273818, 4.3070903506165354], [7.353547552619498, 4.338559051738734], [7.416677674764702, 4.376397790773091], [7.475794963122734, 4.420242159977947], [7.5303300858899105, 4.4696699141100895], [7.579757840022053, 4.524205036877266], [7.623602209226909, 4.583322325235298], [7.661440948261267, 4.646452447380502], [7.6929096493834646, 4.712987425726182], [7.717705251799156, 4.7822864920591535], [7.735588960302422, 4.853682258487904], [7.746388545004148, 4.926487144752829], [7.75, 5.0], [7.746388545004148, 5.07351285524717], [7.735588960302422, 5.146317741512097], [7.717705251799156, 5.2177135079408465], [7.6929096493834646, 5.287012574273818], [7.661440948261266, 5.353547552619498], [7.623602209226909, 5.416677674764702], [7.579757840022053, 5.475794963122734], [7.5303300858899105, 5.5303300858899105], [7.501135760180413, 5.556790280348136], [7.5859375, 5.546875], [8.0703125, 5.465624999999999], [8.53125, 5.3625], [8.96875, 5.2375], [9.4125, 5.1328125], [9.8625, 5.0484374999999995], [10.318750000000001, 4.984375], [10.781249999999998, 4.940625000000001], [11.249999999999998, 4.917187500000001], [11.724999999999998, 4.9140625], [12.206249999999999, 4.9312499999999995], [12.693750000000001, 4.96875], [13.148437500000002, 4.981249999999999], [13.570312500000002, 4.96875], [13.959375000000001, 4.9312499999999995], [14.315625, 4.8687499999999995], [14.639062500000001, 4.78125], [14.9296875, 4.668749999999999], [15.1875, 4.53125], [15.4125, 4.3687499999999995], [15.5, 4.284778225806451], [15.5, 2.45], [15.5, 1.414423076923077], [15.237499999999999, 1.278125], [14.837499999999999, 1.1546875], [14.3625, 1.0765625], [13.8125, 1.0437500000000002], [13.1875, 1.05625], [12.5625, 1.0578125], [11.9375, 1.0484375000000001]]], [[[0.7250000000000001, 16.9375], [0.7640625000000001, 17.78125], [0.7921875, 18.59375], [0.8093750000000001, 19.375], [0.815625, 20.125], [0.8109375000000001, 20.84375], [0.7953125, 21.53125], [0.7687499999999999, 22.1875], [0.7312500000000001, 22.8125], [0.7671875, 23.375], [0.8765624999999999, 23.875], [1.059375, 24.3125], [1.3156249999999998, 24.6875], [1.6453125, 25.0], [5.85, 25.0], [5.9624999999999995, 24.90625], [6.237500000000001, 24.59375], [6.473437500000001, 24.265625], [6.6703125000000005, 23.921875], [6.828125, 23.5625], [6.9468749999999995, 23.1875], [7.026562499999999, 22.796875], [7.067187500000001, 22.390625], [7.0687500000000005, 21.96875], [7.03125, 21.53125], [7.0062500000000005, 21.1015625], [6.99375, 20.6796875], [6.99375, 20.265625], [7.0062500000000005, 19.859375], [7.03125, 19.4609375], [7.068750000000001, 19.0703125], [7.11875, 18.6875], [7.18125, 18.3125], [7.221875000000001, 17.9375], [7.240625000000001, 17.5625], [7.237500000000001, 17.1875], [7.2125, 16.8125], [7.165625, 16.4375], [7.096875000000001, 16.0625], [7.00625, 15.6875], [6.89375, 15.3125], [6.740625, 14.9609375], [6.546874999999999, 14.6328125], [6.3125, 14.328125], [6.0375000000000005, 14.046875], [5.721875000000001, 13.7890625], [5.365625, 13.5546875], [4.96875, 13.34375], [4.53125, 13.15625], [4.109375, 13.0], [3.703125, 12.875], [3.3125, 12.78125], [2.9375, 12.71875], [2.578125, 12.6875], [2.234375, 12.6875], [1.90625, 12.71875], [1.59375, 12.78125], [1.3265625, 12.9453125], [1.1046875, 13.2109375], [0.9281250000000001, 13.578125], [0.7968749999999999, 14.046875], [0.7109374999999999, 14.6171875], [0.6703124999999999, 15.2890625], [0.6749999999999999, 16.0625], [0.7250000000000001, 16.9375]], [[3.2584267283236557, 22.17152999557673], [3.25, 22.0], [3.2584267283236557, 21.82847000442327], [3.2836257592943467, 21.658591936471776], [3.3253544124686343, 21.49200181480469], [3.3832108181052485, 21.330303993361092], [3.456637787390379, 21.175055710554503], [3.5449281784705455, 21.027752092215696], [3.6472317066152105, 20.88981175271362], [3.762563132923542, 20.762563132923542], [3.7744680589134334, 20.751773136955222], [3.8898117527136207, 20.64723170661521], [4.027752092215697, 20.544928178470546], [4.1750557105545045, 20.456637787390378], [4.330303993361093, 20.383210818105248], [4.492001814804691, 20.325354412468634], [4.658591936471776, 20.283625759294345], [4.828470004423269, 20.258426728323656], [5.0, 20.25], [5.171529995576732, 20.258426728323656], [5.341408063528225, 20.283625759294345], [5.507998185195309, 20.325354412468634], [5.669696006638907, 20.383210818105248], [5.824944289445496, 20.456637787390378], [5.972247907784304, 20.544928178470546], [6.11018824728638, 20.64723170661521], [6.237436867076458, 20.762563132923542], [6.3527682933847895, 20.88981175271362], [6.4550718215294545, 21.027752092215696], [6.543362212609622, 21.175055710554503], [6.6167891818947515, 21.330303993361092], [6.674645587531366, 21.49200181480469], [6.716374240705653, 21.658591936471776], [6.741573271676344, 21.82847000442327], [6.75, 22.0], [6.741573271676344, 22.17152999557673], [6.716374240705653, 22.341408063528224], [6.674645587531366, 22.50799818519531], [6.6167891818947515, 22.669696006638908], [6.543362212609621, 22.824944289445497], [6.4550718215294545, 22.972247907784304], [6.352768293384789, 23.11018824728638], [6.2374368670764575, 23.237436867076458], [6.11018824728638, 23.35276829338479], [5.972247907784303, 23.455071821529454], [5.8249442894454955, 23.543362212609622], [5.669696006638907, 23.616789181894752], [5.507998185195309, 23.674645587531366], [5.341408063528225, 23.716374240705655], [5.17152999557673, 23.741573271676344], [5.0, 23.75], [4.828470004423269, 23.741573271676344], [4.658591936471775, 23.716374240705655], [4.4920018148046905, 23.674645587531366], [4.330303993361092, 23.616789181894752], [4.175055710554504, 23.543362212609622], [4.027752092215696, 23.455071821529454], [3.8898117527136193, 23.352768293384788], [3.7625631329235416, 23.237436867076458], [3.64723170661521, 23.11018824728638], [3.5449281784705455, 22.972247907784304], [3.4566377873903784, 22.824944289445497], [3.383210818105248, 22.669696006638908], [3.3253544124686343, 22.50799818519531], [3.2836257592943467, 22.341408063528224], [3.2584267283236557, 22.17152999557673]]]]} | 0.536771 | 123.832 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Planting bed area; 677 individual shrubs modelled and counted separately | SURFACE_GROUP | PK.50.20.C | PK.50.20.C;PK.70.10.C | C_check;C_soil | 2 | 관목 식재지 | 20 수목·녹지 | 군락 면적; 관목 개체 수와 중복 합산하지 않음
shrub_D | 관목·초본식재 / shrub_D | VEGETATION | PK.50.20.D 식재기반 정비 / D구역 (식재기반 정비) | shrub_D | shrub | D | {"type": "MultiPolygon", "coordinates": [[[[38.021875, 0.996875], [37.53125, 0.9125], [36.96875, 0.8875], [36.3984375, 0.8625], [35.8203125, 0.8375], [35.234375, 0.8125], [34.640625, 0.7875000000000001], [34.0390625, 0.7625000000000001], [33.4296875, 0.7375], [32.8125, 0.7125], [32.1875, 0.6875], [31.5546875, 0.6734374999999999], [30.9140625, 0.6703124999999999], [30.265625, 0.6781249999999999], [29.609375, 0.6968749999999999], [28.9453125, 0.7265625], [28.2734375, 0.7671874999999999], [27.59375, 0.81875], [26.90625, 0.8812500000000001], [26.3046875, 0.9828125000000001], [25.7890625, 1.1234375], [25.359375, 1.303125], [25.015625, 1.521875], [24.7578125, 1.7796875], [24.5859375, 2.0765625], [24.5, 2.4125], [24.5, 2.7874999999999996], [24.5390625, 3.1531249999999997], [24.6171875, 3.5093749999999995], [24.734375, 3.8562499999999993], [24.890625, 4.193749999999999], [24.92627550521199, 4.253642848756145], [24.92648714475283, 4.253611454995852], [25.0, 4.25], [25.07351285524717, 4.253611454995852], [25.146317741512096, 4.264411039697578], [25.217713507940847, 4.282294748200844], [25.287012574273817, 4.3070903506165354], [25.3535475526195, 4.338559051738734], [25.416677674764703, 4.376397790773091], [25.475794963122734, 4.420242159977947], [25.53033008588991, 4.4696699141100895], [25.579757840022054, 4.524205036877266], [25.62360220922691, 4.583322325235298], [25.661440948261266, 4.646452447380502], [25.692909649383466, 4.712987425726182], [25.717705251799156, 4.7822864920591535], [25.735588960302422, 4.853682258487904], [25.746388545004148, 4.926487144752829], [25.75, 5.0], [25.746388545004148, 5.07351285524717], [25.735588960302422, 5.146317741512097], [25.717705251799156, 5.2177135079408465], [25.704047171651442, 5.255885284785383], [25.90625, 5.45], [26.25, 5.6890625], [26.625, 5.867187500000001], [27.03125, 5.984375], [27.46875, 6.0406249999999995], [27.9375, 6.035937499999999], [28.4375, 5.9703125], [28.96875, 5.84375], [29.53125, 5.65625], [30.0625, 5.5140625], [30.5625, 5.417187500000001], [31.03125, 5.3656250000000005], [31.46875, 5.359375], [31.875, 5.398437499999999], [32.25, 5.4828125], [32.59375, 5.6125], [32.90625, 5.7875], [33.2359375, 5.946875], [33.5828125, 6.090625], [33.946875000000006, 6.21875], [34.328125, 6.331250000000001], [34.7265625, 6.4281250000000005], [35.14218749999999, 6.509375], [35.574999999999996, 6.575], [36.025, 6.625], [36.446875, 6.640625], [36.840625, 6.621874999999999], [37.206250000000004, 6.56875], [37.54375, 6.481249999999999], [37.853125000000006, 6.359374999999999], [38.134375, 6.203124999999999], [38.387499999999996, 6.012499999999999], [38.612500000000004, 5.7875000000000005], [38.8109375, 5.528125000000001], [38.982812499999994, 5.234375], [39.128125, 4.90625], [39.246874999999996, 4.543749999999999], [39.3390625, 4.146875], [39.4046875, 3.715625], [39.44375, 3.25], [39.446115288220554, 3.1553884711779445], [39.456250000000004, 2.75], [39.39687500000001, 2.309375], [39.265625, 1.928125], [39.0625, 1.6062500000000002], [38.787499999999994, 1.34375], [38.440625, 1.140625], [38.021875, 0.996875]], [[35.579757840022054, 4.975794963122734], [35.53033008588991, 5.0303300858899105], [35.47579496312274, 5.079757840022053], [35.4166776747647, 5.12360220922691], [35.353547552619496, 5.161440948261267], [35.28701257427382, 5.1929096493834646], [35.21771350794084, 5.217705251799156], [35.1463177415121, 5.235588960302422], [35.07351285524717, 5.246388545004148], [35.0, 5.25], [34.92648714475283, 5.246388545004148], [34.8536822584879, 5.235588960302422], [34.78228649205915, 5.217705251799156], [34.71298742572618, 5.1929096493834646], [34.646452447380504, 5.161440948261266], [34.5833223252353, 5.123602209226909], [34.52420503687726, 5.079757840022053], [34.46966991411009, 5.0303300858899105], [34.420242159977946, 4.975794963122734], [34.37639779077309, 4.916677674764702], [34.338559051738734, 4.853547552619498], [34.307090350616534, 4.787012574273818], [34.28229474820084, 4.7177135079408465], [34.26441103969758, 4.646317741512096], [34.253611454995855, 4.57351285524717], [34.25, 4.5], [34.253611454995855, 4.426487144752829], [34.26441103969758, 4.353682258487903], [34.28229474820084, 4.2822864920591535], [34.307090350616534, 4.212987425726182], [34.338559051738734, 4.146452447380502], [34.37639779077309, 4.083322325235298], [34.420242159977946, 4.024205036877266], [34.46966991411009, 3.9696699141100895], [34.52420503687726, 3.9202421599779473], [34.5833223252353, 3.876397790773091], [34.646452447380504, 3.838559051738734], [34.71298742572618, 3.807090350616535], [34.78228649205915, 3.7822947482008433], [34.8536822584879, 3.764411039697577], [34.92648714475283, 3.7536114549958524], [35.0, 3.75], [35.07351285524717, 3.7536114549958524], [35.1463177415121, 3.764411039697577], [35.21771350794085, 3.7822947482008433], [35.28701257427382, 3.807090350616535], [35.353547552619496, 3.838559051738734], [35.4166776747647, 3.8763977907730913], [35.47579496312274, 3.9202421599779473], [35.53033008588991, 3.9696699141100895], [35.579757840022054, 4.024205036877266], [35.62360220922691, 4.083322325235298], [35.661440948261266, 4.146452447380502], [35.692909649383466, 4.212987425726182], [35.71770525179916, 4.2822864920591535], [35.73558896030242, 4.353682258487904], [35.746388545004145, 4.426487144752829], [35.75, 4.5], [35.746388545004145, 4.57351285524717], [35.73558896030242, 4.646317741512097], [35.71770525179916, 4.7177135079408465], [35.692909649383466, 4.787012574273818], [35.661440948261266, 4.853547552619498], [35.62360220922691, 4.916677674764702], [35.579757840022054, 4.975794963122734]]], [[[33.154687499999994, 24.98125], [33.148054245283014, 25.0], [38.7578125, 25.0], [38.545312499999994, 24.8], [38.231249999999996, 24.587500000000002], [37.86875, 24.412499999999998], [37.5, 24.2625], [37.125, 24.137500000000003], [36.95726167598353, 24.093503062553058], [36.9166776747647, 24.12360220922691], [36.853547552619496, 24.161440948261266], [36.78701257427382, 24.192909649383466], [36.71771350794084, 24.217705251799156], [36.6463177415121, 24.235588960302422], [36.57351285524717, 24.246388545004148], [36.5, 24.25], [36.42648714475283, 24.246388545004148], [36.3536822584879, 24.235588960302422], [36.28228649205915, 24.217705251799156], [36.21298742572618, 24.192909649383466], [36.146452447380504, 24.161440948261266], [36.0833223252353, 24.12360220922691], [36.02420503687726, 24.07975784002205], [35.96966991411009, 24.03033008588991], [35.920242159977946, 23.975794963122734], [35.87639779077309, 23.916677674764703], [35.8704453232657, 23.90674658270411], [35.78521293375395, 23.901419558359624], [35.5625, 23.887500000000003], [35.15625, 23.887500000000003], [34.743750000000006, 23.912499999999998], [34.3734375, 23.981249999999996], [34.0453125, 24.093749999999996], [33.759375000000006, 24.249999999999996], [33.515625, 24.450000000000003], [33.3140625, 24.69375], [33.154687499999994, 24.98125]]]]} | 0.184535 | 75.2564 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Planting bed area; 677 individual shrubs modelled and counted separately | SURFACE_GROUP | PK.50.20.D | PK.50.20.D;PK.70.10.D | D_check;D_soil | 2 | 관목 식재지 | 20 수목·녹지 | 군락 면적; 관목 개체 수와 중복 합산하지 않음
green_A | 일반녹지 / green_A | VEGETATION | PK.50.60.A 수목 하부 멀칭 / A구역 (수목 하부 멀칭) | green_A | green | A | {"type": "MultiPolygon", "coordinates": [[[[3.616677674764702, 25.87639779077309], [3.5535475526194986, 25.838559051738734], [3.4870125742738174, 25.807090350616534], [3.4177135079408467, 25.782294748200844], [3.3463177415120966, 25.764411039697578], [3.2735128552471706, 25.753611454995852], [3.2, 25.75], [3.1264871447528297, 25.753611454995852], [3.053682258487904, 25.764411039697578], [2.9822864920591536, 25.782294748200844], [2.912987425726183, 25.807090350616534], [2.8464524473805017, 25.838559051738734], [2.7833223252352988, 25.87639779077309], [2.724205036877266, 25.920242159977946], [2.6696699141100897, 25.96966991411009], [2.6202421599779475, 26.024205036877266], [2.576397790773091, 26.083322325235297], [2.538559051738734, 26.1464524473805], [2.507090350616535, 26.212987425726183], [2.4822947482008435, 26.282286492059153], [2.4644110396975774, 26.353682258487904], [2.4536114549958525, 26.42648714475283], [2.45, 26.5], [2.4536114549958525, 26.57351285524717], [2.4644110396975774, 26.646317741512096], [2.4822947482008435, 26.717713507940847], [2.507090350616535, 26.787012574273817], [2.538559051738734, 26.8535475526195], [2.576397790773091, 26.916677674764703], [2.6202421599779475, 26.975794963122734], [2.6696699141100897, 27.03033008588991], [2.7242050368772657, 27.07975784002205], [2.7833223252352983, 27.12360220922691], [2.8464524473805017, 27.161440948261266], [2.9129874257261825, 27.192909649383466], [2.982286492059153, 27.217705251799156], [3.0536822584879038, 27.235588960302422], [3.1264871447528297, 27.246388545004148], [3.2, 27.25], [3.27351285524717, 27.246388545004148], [3.3463177415120966, 27.235588960302422], [3.4177135079408467, 27.217705251799156], [3.487012574273818, 27.192909649383466], [3.5535475526194986, 27.161440948261266], [3.6166776747647016, 27.12360220922691], [3.6757949631227342, 27.079757840022054], [3.7303300858899107, 27.03033008588991], [3.779757840022053, 26.975794963122734], [3.823602209226909, 26.916677674764703], [3.8614409482612664, 26.8535475526195], [3.892909649383465, 26.787012574273817], [3.917705251799157, 26.717713507940847], [3.935588960302423, 26.646317741512096], [3.946388545004148, 26.57351285524717], [3.95, 26.5], [3.946388545004148, 26.42648714475283], [3.935588960302423, 26.353682258487904], [3.917705251799157, 26.282286492059153], [3.892909649383465, 26.212987425726183], [3.8614409482612664, 26.1464524473805], [3.823602209226909, 26.083322325235297], [3.779757840022053, 26.024205036877266], [3.7303300858899107, 25.96966991411009], [3.6757949631227342, 25.920242159977946], [3.616677674764702, 25.87639779077309]]], [[[3.416677674764702, 36.37639779077309], [3.3535475526194984, 36.338559051738734], [3.287012574273817, 36.307090350616534], [3.2177135079408465, 36.28229474820084], [3.1463177415120964, 36.26441103969758], [3.0735128552471704, 36.253611454995855], [3.0, 36.25], [2.9264871447528296, 36.253611454995855], [2.853682258487904, 36.26441103969758], [2.7822864920591535, 36.28229474820084], [2.712987425726183, 36.307090350616534], [2.6464524473805016, 36.338559051738734], [2.5833223252352986, 36.37639779077309], [2.524205036877266, 36.420242159977946], [2.4696699141100895, 36.46966991411009], [2.4202421599779473, 36.52420503687726], [2.376397790773091, 36.5833223252353], [2.338559051738734, 36.646452447380504], [2.307090350616535, 36.71298742572618], [2.2822947482008433, 36.78228649205915], [2.264411039697577, 36.8536822584879], [2.2536114549958524, 36.92648714475283], [2.25, 37.0], [2.2536114549958524, 37.07351285524717], [2.264411039697577, 37.1463177415121], [2.2822947482008433, 37.21771350794085], [2.307090350616535, 37.28701257427382], [2.338559051738734, 37.353547552619496], [2.376397790773091, 37.4166776747647], [2.4202421599779473, 37.47579496312273], [2.4696699141100895, 37.53033008588991], [2.5242050368772655, 37.579757840022054], [2.583322325235298, 37.62360220922691], [2.6464524473805016, 37.661440948261266], [2.7129874257261823, 37.692909649383466], [2.782286492059153, 37.71770525179916], [2.8536822584879036, 37.73558896030242], [2.9264871447528296, 37.746388545004145], [3.0, 37.75], [3.07351285524717, 37.746388545004145], [3.1463177415120964, 37.73558896030242], [3.2177135079408465, 37.71770525179916], [3.2870125742738177, 37.692909649383466], [3.3535475526194984, 37.661440948261266], [3.4166776747647014, 37.62360220922691], [3.475794963122734, 37.579757840022054], [3.5303300858899105, 37.53033008588991], [3.5797578400220527, 37.47579496312274], [3.6236022092269087, 37.4166776747647], [3.661440948261266, 37.353547552619496], [3.692909649383465, 37.28701257427382], [3.7177052517991567, 37.21771350794085], [3.735588960302423, 37.1463177415121], [3.7463885450041476, 37.07351285524717], [3.75, 37.0], [3.7463885450041476, 36.92648714475283], [3.735588960302423, 36.8536822584879], [3.7177052517991567, 36.78228649205915], [3.692909649383465, 36.71298742572618], [3.661440948261266, 36.646452447380504], [3.6236022092269087, 36.5833223252353], [3.5797578400220527, 36.52420503687726], [3.5303300858899105, 36.46966991411009], [3.475794963122734, 36.420242159977946], [3.416677674764702, 36.37639779077309]]], [[[11.416677674764701, 43.17639779077309], [11.353547552619498, 43.13855905173873], [11.287012574273817, 43.10709035061653], [11.217713507940847, 43.08229474820084], [11.146317741512096, 43.064411039697575], [11.07351285524717, 43.05361145499585], [11.0, 43.05], [10.92648714475283, 43.05361145499585], [10.853682258487904, 43.064411039697575], [10.782286492059153, 43.08229474820084], [10.712987425726183, 43.10709035061653], [10.646452447380502, 43.13855905173873], [10.583322325235299, 43.17639779077309], [10.524205036877266, 43.22024215997794], [10.469669914110089, 43.26966991411009], [10.420242159977947, 43.32420503687726], [10.37639779077309, 43.3833223252353], [10.338559051738734, 43.4464524473805], [10.307090350616535, 43.51298742572618], [10.282294748200844, 43.58228649205915], [10.264411039697578, 43.6536822584879], [10.253611454995852, 43.726487144752824], [10.25, 43.8], [10.253611454995852, 43.87351285524717], [10.264411039697578, 43.9463177415121], [10.282294748200844, 44.01771350794085], [10.307090350616535, 44.087012574273814], [10.338559051738734, 44.15354755261949], [10.37639779077309, 44.216677674764696], [10.420242159977947, 44.27579496312273], [10.469669914110089, 44.330330085889905], [10.524205036877266, 44.37975784002205], [10.583322325235299, 44.42360220922691], [10.646452447380502, 44.46144094826126], [10.712987425726181, 44.49290964938346], [10.782286492059153, 44.51770525179916], [10.853682258487904, 44.53558896030242], [10.92648714475283, 44.54638854500414], [11.0, 44.55], [11.07351285524717, 44.54638854500414], [11.146317741512096, 44.53558896030242], [11.217713507940847, 44.51770525179916], [11.287012574273817, 44.49290964938346], [11.353547552619498, 44.46144094826126], [11.416677674764701, 44.42360220922691], [11.475794963122734, 44.37975784002205], [11.530330085889911, 44.330330085889905], [11.579757840022053, 44.275794963122735], [11.62360220922691, 44.216677674764696], [11.661440948261266, 44.15354755261949], [11.692909649383465, 44.087012574273814], [11.717705251799156, 44.01771350794085], [11.735588960302422, 43.9463177415121], [11.746388545004148, 43.87351285524717], [11.75, 43.8], [11.746388545004148, 43.726487144752824], [11.735588960302422, 43.6536822584879], [11.717705251799156, 43.58228649205915], [11.692909649383465, 43.51298742572618], [11.661440948261266, 43.4464524473805], [11.62360220922691, 43.3833223252353], [11.579757840022053, 43.32420503687726], [11.530330085889911, 43.26966991411009], [11.475794963122734, 43.22024215997794], [11.416677674764701, 43.17639779077309]]], [[[18.916677674764703, 45.37639779077309], [18.8535475526195, 45.338559051738734], [18.787012574273817, 45.307090350616534], [18.717713507940847, 45.28229474820084], [18.646317741512096, 45.26441103969758], [18.57351285524717, 45.253611454995855], [18.5, 45.25], [18.42648714475283, 45.253611454995855], [18.353682258487904, 45.26441103969758], [18.282286492059153, 45.28229474820084], [18.212987425726183, 45.307090350616534], [18.1464524473805, 45.338559051738734], [18.083322325235297, 45.37639779077309], [18.024205036877266, 45.420242159977946], [17.96966991411009, 45.46966991411009], [17.920242159977946, 45.52420503687726], [17.87639779077309, 45.5833223252353], [17.838559051738734, 45.646452447380504], [17.807090350616534, 45.71298742572618], [17.782294748200844, 45.78228649205915], [17.764411039697578, 45.8536822584879], [17.753611454995852, 45.92648714475283], [17.75, 46.0], [17.753611454995852, 46.07351285524717], [17.764411039697578, 46.1463177415121], [17.782294748200844, 46.21771350794085], [17.807090350616534, 46.28701257427382], [17.838559051738734, 46.353547552619496], [17.87639779077309, 46.4166776747647], [17.920242159977946, 46.47579496312273], [17.96966991411009, 46.53033008588991], [18.024205036877266, 46.579757840022054], [18.083322325235297, 46.62360220922691], [18.1464524473805, 46.661440948261266], [18.212987425726183, 46.692909649383466], [18.282286492059153, 46.71770525179916], [18.353682258487904, 46.73558896030242], [18.42648714475283, 46.746388545004145], [18.5, 46.75], [18.57351285524717, 46.746388545004145], [18.646317741512096, 46.73558896030242], [18.717713507940847, 46.71770525179916], [18.787012574273817, 46.692909649383466], [18.8535475526195, 46.661440948261266], [18.916677674764703, 46.62360220922691], [18.975794963122734, 46.579757840022054], [19.03033008588991, 46.53033008588991], [19.07975784002205, 46.47579496312274], [19.12360220922691, 46.4166776747647], [19.161440948261266, 46.353547552619496], [19.192909649383466, 46.28701257427382], [19.217705251799156, 46.21771350794085], [19.235588960302422, 46.1463177415121], [19.246388545004148, 46.07351285524717], [19.25, 46.0], [19.246388545004148, 45.92648714475283], [19.235588960302422, 45.8536822584879], [19.217705251799156, 45.78228649205915], [19.192909649383466, 45.71298742572618], [19.161440948261266, 45.646452447380504], [19.12360220922691, 45.5833223252353], [19.079757840022054, 45.52420503687726], [19.03033008588991, 45.46966991411009], [18.975794963122734, 45.420242159977946], [18.916677674764703, 45.37639779077309]]]]} | 1.15116 | 7.05723 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 |  | SURFACE_GROUP | PK.50.60.A | PK.50.20.A;PK.50.60.A;PK.70.10.A | A_check;A_mulch;A_soil | 3 | 수목 하부 멀칭 | 20 수목·녹지 | 신규 교목 하부 멀칭 면적
