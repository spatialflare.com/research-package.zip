Properties of the parts of a building model (IFC4X3_ADD2), part 6 of 9

# IfcGeographicElement: 회양목 H0.4 X W0.5 (181)
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_B02-014 | 관목 개체 / P2_B02-014 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-014 | D | {"type": "Point", "coordinates": [33.195, 1.3766264720814412]} | 0.126854 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-015 | 관목 개체 / P2_B02-015 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-015 | D | {"type": "Point", "coordinates": [33.745, 1.3766264720814412]} | 0.118604 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-016 | 관목 개체 / P2_B02-016 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-016 | D | {"type": "Point", "coordinates": [34.294999999999995, 1.3766264720814412]} | 0.110354 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-017 | 관목 개체 / P2_B02-017 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-017 | D | {"type": "Point", "coordinates": [34.84499999999999, 1.3766264720814412]} | 0.102104 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-018 | 관목 개체 / P2_B02-018 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-018 | D | {"type": "Point", "coordinates": [35.39499999999999, 1.3766264720814412]} | 0.0938543 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-019 | 관목 개체 / P2_B02-019 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-019 | D | {"type": "Point", "coordinates": [35.944999999999986, 1.3766264720814412]} | 0.0856043 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-020 | 관목 개체 / P2_B02-020 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-020 | D | {"type": "Point", "coordinates": [36.49499999999998, 1.3766264720814412]} | 0.0773543 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-021 | 관목 개체 / P2_B02-021 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-021 | D | {"type": "Point", "coordinates": [37.04499999999998, 1.3766264720814412]} | 0.0691043 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-022 | 관목 개체 / P2_B02-022 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-022 | D | {"type": "Point", "coordinates": [37.59499999999998, 1.3766264720814412]} | 0.0608543 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-023 | 관목 개체 / P2_B02-023 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-023 | D | {"type": "Point", "coordinates": [38.144999999999975, 1.3766264720814412]} | 0.0526043 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-024 | 관목 개체 / P2_B02-024 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-024 | D | {"type": "Point", "coordinates": [25.220000000000002, 1.8529404441628823]} | 0.255053 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-025 | 관목 개체 / P2_B02-025 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-025 | D | {"type": "Point", "coordinates": [25.770000000000003, 1.8529404441628823]} | 0.246803 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-026 | 관목 개체 / P2_B02-026 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-026 | D | {"type": "Point", "coordinates": [26.320000000000004, 1.8529404441628823]} | 0.238553 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-027 | 관목 개체 / P2_B02-027 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-027 | D | {"type": "Point", "coordinates": [26.870000000000005, 1.8529404441628823]} | 0.230303 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-028 | 관목 개체 / P2_B02-028 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-028 | D | {"type": "Point", "coordinates": [27.420000000000005, 1.8529404441628823]} | 0.222053 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-029 | 관목 개체 / P2_B02-029 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-029 | D | {"type": "Point", "coordinates": [27.970000000000006, 1.8529404441628823]} | 0.213803 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-030 | 관목 개체 / P2_B02-030 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-030 | D | {"type": "Point", "coordinates": [28.520000000000007, 1.8529404441628823]} | 0.205553 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-031 | 관목 개체 / P2_B02-031 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-031 | D | {"type": "Point", "coordinates": [29.070000000000007, 1.8529404441628823]} | 0.197303 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-032 | 관목 개체 / P2_B02-032 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-032 | D | {"type": "Point", "coordinates": [29.620000000000008, 1.8529404441628823]} | 0.189053 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-033 | 관목 개체 / P2_B02-033 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-033 | D | {"type": "Point", "coordinates": [30.17000000000001, 1.8529404441628823]} | 0.180803 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-034 | 관목 개체 / P2_B02-034 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-034 | D | {"type": "Point", "coordinates": [30.72000000000001, 1.8529404441628823]} | 0.172553 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-035 | 관목 개체 / P2_B02-035 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-035 | D | {"type": "Point", "coordinates": [31.27000000000001, 1.8529404441628823]} | 0.164303 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-036 | 관목 개체 / P2_B02-036 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-036 | D | {"type": "Point", "coordinates": [31.82000000000001, 1.8529404441628823]} | 0.156053 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-037 | 관목 개체 / P2_B02-037 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-037 | D | {"type": "Point", "coordinates": [32.37000000000001, 1.8529404441628823]} | 0.147803 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-038 | 관목 개체 / P2_B02-038 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-038 | D | {"type": "Point", "coordinates": [32.92000000000001, 1.8529404441628823]} | 0.139553 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-039 | 관목 개체 / P2_B02-039 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-039 | D | {"type": "Point", "coordinates": [33.470000000000006, 1.8529404441628823]} | 0.131303 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-040 | 관목 개체 / P2_B02-040 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-040 | D | {"type": "Point", "coordinates": [34.02, 1.8529404441628823]} | 0.123053 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-041 | 관목 개체 / P2_B02-041 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-041 | D | {"type": "Point", "coordinates": [34.57, 1.8529404441628823]} | 0.114803 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-042 | 관목 개체 / P2_B02-042 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-042 | D | {"type": "Point", "coordinates": [35.12, 1.8529404441628823]} | 0.106553 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-043 | 관목 개체 / P2_B02-043 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-043 | D | {"type": "Point", "coordinates": [35.669999999999995, 1.8529404441628823]} | 0.0983029 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-044 | 관목 개체 / P2_B02-044 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-044 | D | {"type": "Point", "coordinates": [36.21999999999999, 1.8529404441628823]} | 0.0900529 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-045 | 관목 개체 / P2_B02-045 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-045 | D | {"type": "Point", "coordinates": [36.76999999999999, 1.8529404441628823]} | 0.0818029 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-046 | 관목 개체 / P2_B02-046 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-046 | D | {"type": "Point", "coordinates": [37.319999999999986, 1.8529404441628823]} | 0.0735529 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-047 | 관목 개체 / P2_B02-047 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-047 | D | {"type": "Point", "coordinates": [37.86999999999998, 1.8529404441628823]} | 0.0653029 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-048 | 관목 개체 / P2_B02-048 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-048 | D | {"type": "Point", "coordinates": [38.41999999999998, 1.8529404441628823]} | 0.0570529 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-049 | 관목 개체 / P2_B02-049 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-049 | D | {"type": "Point", "coordinates": [24.945, 2.3292544162443236]} | 0.267752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-050 | 관목 개체 / P2_B02-050 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-050 | D | {"type": "Point", "coordinates": [25.495, 2.3292544162443236]} | 0.259502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-051 | 관목 개체 / P2_B02-051 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-051 | D | {"type": "Point", "coordinates": [26.045, 2.3292544162443236]} | 0.251252 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-052 | 관목 개체 / P2_B02-052 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-052 | D | {"type": "Point", "coordinates": [26.595000000000002, 2.3292544162443236]} | 0.243002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-053 | 관목 개체 / P2_B02-053 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-053 | D | {"type": "Point", "coordinates": [27.145000000000003, 2.3292544162443236]} | 0.234752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-054 | 관목 개체 / P2_B02-054 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-054 | D | {"type": "Point", "coordinates": [27.695000000000004, 2.3292544162443236]} | 0.226502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-055 | 관목 개체 / P2_B02-055 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-055 | D | {"type": "Point", "coordinates": [28.245000000000005, 2.3292544162443236]} | 0.218252 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-056 | 관목 개체 / P2_B02-056 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-056 | D | {"type": "Point", "coordinates": [28.795000000000005, 2.3292544162443236]} | 0.210002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-057 | 관목 개체 / P2_B02-057 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-057 | D | {"type": "Point", "coordinates": [29.345000000000006, 2.3292544162443236]} | 0.201752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-058 | 관목 개체 / P2_B02-058 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-058 | D | {"type": "Point", "coordinates": [29.895000000000007, 2.3292544162443236]} | 0.193502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-059 | 관목 개체 / P2_B02-059 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-059 | D | {"type": "Point", "coordinates": [30.445000000000007, 2.3292544162443236]} | 0.185252 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-060 | 관목 개체 / P2_B02-060 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-060 | D | {"type": "Point", "coordinates": [30.995000000000008, 2.3292544162443236]} | 0.177002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-061 | 관목 개체 / P2_B02-061 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-061 | D | {"type": "Point", "coordinates": [31.54500000000001, 2.3292544162443236]} | 0.168752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-062 | 관목 개체 / P2_B02-062 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-062 | D | {"type": "Point", "coordinates": [32.095000000000006, 2.3292544162443236]} | 0.160502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-063 | 관목 개체 / P2_B02-063 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-063 | D | {"type": "Point", "coordinates": [32.645, 2.3292544162443236]} | 0.152252 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-064 | 관목 개체 / P2_B02-064 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-064 | D | {"type": "Point", "coordinates": [33.195, 2.3292544162443236]} | 0.144002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-065 | 관목 개체 / P2_B02-065 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-065 | D | {"type": "Point", "coordinates": [33.745, 2.3292544162443236]} | 0.135752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-066 | 관목 개체 / P2_B02-066 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-066 | D | {"type": "Point", "coordinates": [34.294999999999995, 2.3292544162443236]} | 0.127502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-067 | 관목 개체 / P2_B02-067 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-067 | D | {"type": "Point", "coordinates": [34.84499999999999, 2.3292544162443236]} | 0.119252 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-068 | 관목 개체 / P2_B02-068 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-068 | D | {"type": "Point", "coordinates": [35.39499999999999, 2.3292544162443236]} | 0.111002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-069 | 관목 개체 / P2_B02-069 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-069 | D | {"type": "Point", "coordinates": [35.944999999999986, 2.3292544162443236]} | 0.102752 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-070 | 관목 개체 / P2_B02-070 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-070 | D | {"type": "Point", "coordinates": [36.49499999999998, 2.3292544162443236]} | 0.0945016 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-071 | 관목 개체 / P2_B02-071 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-071 | D | {"type": "Point", "coordinates": [37.04499999999998, 2.3292544162443236]} | 0.0862516 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-072 | 관목 개체 / P2_B02-072 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-072 | D | {"type": "Point", "coordinates": [37.59499999999998, 2.3292544162443236]} | 0.0780016 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-073 | 관목 개체 / P2_B02-073 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-073 | D | {"type": "Point", "coordinates": [38.144999999999975, 2.3292544162443236]} | 0.0697516 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-074 | 관목 개체 / P2_B02-074 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-074 | D | {"type": "Point", "coordinates": [38.69499999999997, 2.3292544162443236]} | 0.0615016 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-075 | 관목 개체 / P2_B02-075 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-075 | D | {"type": "Point", "coordinates": [25.220000000000002, 2.805568388325765]} | 0.2722 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-076 | 관목 개체 / P2_B02-076 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-076 | D | {"type": "Point", "coordinates": [25.770000000000003, 2.805568388325765]} | 0.26395 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-077 | 관목 개체 / P2_B02-077 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-077 | D | {"type": "Point", "coordinates": [26.320000000000004, 2.805568388325765]} | 0.2557 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-078 | 관목 개체 / P2_B02-078 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-078 | D | {"type": "Point", "coordinates": [26.870000000000005, 2.805568388325765]} | 0.24745 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-079 | 관목 개체 / P2_B02-079 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-079 | D | {"type": "Point", "coordinates": [27.420000000000005, 2.805568388325765]} | 0.2392 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-080 | 관목 개체 / P2_B02-080 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-080 | D | {"type": "Point", "coordinates": [27.970000000000006, 2.805568388325765]} | 0.23095 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-081 | 관목 개체 / P2_B02-081 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-081 | D | {"type": "Point", "coordinates": [28.520000000000007, 2.805568388325765]} | 0.2227 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-082 | 관목 개체 / P2_B02-082 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-082 | D | {"type": "Point", "coordinates": [29.070000000000007, 2.805568388325765]} | 0.21445 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-083 | 관목 개체 / P2_B02-083 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-083 | D | {"type": "Point", "coordinates": [29.620000000000008, 2.805568388325765]} | 0.2062 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-084 | 관목 개체 / P2_B02-084 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-084 | D | {"type": "Point", "coordinates": [35.12, 2.805568388325765]} | 0.1237 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-085 | 관목 개체 / P2_B02-085 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-085 | D | {"type": "Point", "coordinates": [35.669999999999995, 2.805568388325765]} | 0.11545 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-086 | 관목 개체 / P2_B02-086 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-086 | D | {"type": "Point", "coordinates": [36.21999999999999, 2.805568388325765]} | 0.1072 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-087 | 관목 개체 / P2_B02-087 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-087 | D | {"type": "Point", "coordinates": [36.76999999999999, 2.805568388325765]} | 0.0989502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-088 | 관목 개체 / P2_B02-088 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-088 | D | {"type": "Point", "coordinates": [37.319999999999986, 2.805568388325765]} | 0.0907002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-089 | 관목 개체 / P2_B02-089 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-089 | D | {"type": "Point", "coordinates": [37.86999999999998, 2.805568388325765]} | 0.0824502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-090 | 관목 개체 / P2_B02-090 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-090 | D | {"type": "Point", "coordinates": [38.41999999999998, 2.805568388325765]} | 0.0742002 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-091 | 관목 개체 / P2_B02-091 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-091 | D | {"type": "Point", "coordinates": [38.96999999999998, 2.805568388325765]} | 0.0659502 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-092 | 관목 개체 / P2_B02-092 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-092 | D | {"type": "Point", "coordinates": [25.495, 3.281882360407206]} | 0.276649 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-093 | 관목 개체 / P2_B02-093 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-093 | D | {"type": "Point", "coordinates": [26.045, 3.281882360407206]} | 0.268399 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-094 | 관목 개체 / P2_B02-094 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-094 | D | {"type": "Point", "coordinates": [26.595000000000002, 3.281882360407206]} | 0.260149 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-095 | 관목 개체 / P2_B02-095 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-095 | D | {"type": "Point", "coordinates": [27.145000000000003, 3.281882360407206]} | 0.251899 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-096 | 관목 개체 / P2_B02-096 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-096 | D | {"type": "Point", "coordinates": [27.695000000000004, 3.281882360407206]} | 0.243649 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-097 | 관목 개체 / P2_B02-097 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-097 | D | {"type": "Point", "coordinates": [28.245000000000005, 3.281882360407206]} | 0.235399 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-098 | 관목 개체 / P2_B02-098 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-098 | D | {"type": "Point", "coordinates": [37.04499999999998, 3.281882360407206]} | 0.103399 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-099 | 관목 개체 / P2_B02-099 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-099 | D | {"type": "Point", "coordinates": [37.59499999999998, 3.281882360407206]} | 0.0951489 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-100 | 관목 개체 / P2_B02-100 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-100 | D | {"type": "Point", "coordinates": [38.144999999999975, 3.281882360407206]} | 0.0868989 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs

# IfcKerb: curb (4)
In: Local synthetic site; not georeferenced
Material: Granite; Group: 10 포장·경계·지형
LCS_Provenance - Kind: curb; Source: SYNTHETIC
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Width_m: 0.15; Height_m: 0.2; ExposedHeight_m: 0.08; Position: Outside clear paving width; LedgerLengthBasis: Paving-side edge; corner band mesh volume is not ledger volume
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 화강석 경계석; NurseryOrFacilitySpecification: 150×200mm (가정); ClassificationVersion: R1-WBS2
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | cover (m2) | curb_install (m) | PrimaryWBS | WBSCodeList | LegacyTaskIds
CURB_A | 화강석 경계석 / CURB_A | PK.30.20.A 화강석 경계석 설치 / A구역 (화강석 경계석 설치) | CURB_A | A | {"type": "MultiPolygon", "coordinates": [[[[20.0, 38.0], [20.0, 37.85], [10.15, 37.85], [10.15, 25.0], [10.0, 25.0], [10.0, 38.0], [20.0, 38.0]]], [[[4.85, 26.85], [4.85, 31.15], [7.85, 31.15], [7.85, 40.15], [12.85, 40.15], [12.85, 43.15], [19.15, 43.15], [19.15, 40.15], [20.0, 40.15], [20.0, 40.0], [19.0, 40.0], [19.0, 43.0], [13.0, 43.0], [13.0, 40.0], [8.0, 40.0], [8.0, 31.0], [5.0, 31.0], [5.0, 27.0], [8.0, 27.0], [8.0, 25.0], [7.85, 25.0], [7.85, 26.85], [4.85, 26.85]]]]} | 1.01452 | 9.3 | 62 | PK.30.20.A | PK.30.20.A;PK.70.10.A | A_check;A_curb
CURB_B | 화강석 경계석 / CURB_B | PK.30.20.B 화강석 경계석 설치 / B구역 (화강석 경계석 설치) | CURB_B | B | {"type": "MultiPolygon", "coordinates": [[[[30.0, 25.0], [29.85, 25.0], [29.85, 37.85], [20.0, 37.85], [20.0, 38.0], [30.0, 38.0], [30.0, 25.0]]], [[[32.15, 25.0], [32.0, 25.0], [32.0, 40.0], [20.0, 40.0], [20.0, 40.15], [32.15, 40.15], [32.15, 25.0]]]]} | 0.716775 | 7.5 | 50 | PK.30.20.B | PK.30.20.B;PK.70.10.B | B_check;B_curb
CURB_C | 화강석 경계석 / CURB_C | PK.30.20.C 화강석 경계석 설치 / C구역 (화강석 경계석 설치) | CURB_C | C | {"type": "MultiPolygon", "coordinates": [[[[7.85, 9.85], [7.85, 25.0], [8.0, 25.0], [8.0, 10.0], [9.0, 10.0], [9.0, 6.0], [15.0, 6.0], [15.0, 10.0], [19.0, 10.0], [19.0, 4.0], [16.0, 4.0], [16.0, 0.0], [15.85, 0.0], [15.85, 4.15], [18.85, 4.15], [18.85, 9.85], [15.15, 9.85], [15.15, 5.85], [8.85, 5.85], [8.85, 9.85], [7.85, 9.85]]], [[[10.0, 25.0], [10.15, 25.0], [10.15, 12.15], [20.0, 12.15], [20.0, 12.0], [10.0, 12.0], [10.0, 25.0]]]]} | 0.796125 | 10.4775 | 70 | PK.30.20.C | PK.30.20.C;PK.70.10.C | C_check;C_curb
CURB_D | 화강석 경계석 / CURB_D | PK.30.20.D 화강석 경계석 설치 / D구역 (화강석 경계석 설치) | CURB_D | D | {"type": "MultiPolygon", "coordinates": [[[[38.15, 22.15], [38.15, 11.85], [32.15, 11.85], [32.15, 9.85], [21.15, 9.85], [21.15, 4.15], [24.15, 4.15], [24.15, 0.0], [24.0, 0.0], [24.0, 4.0], [21.0, 4.0], [21.0, 10.0], [32.0, 10.0], [32.0, 12.0], [38.0, 12.0], [38.0, 22.0], [32.0, 22.0], [32.0, 25.0], [32.15, 25.0], [32.15, 22.15], [38.15, 22.15]]], [[[20.0, 12.0], [20.0, 12.15], [29.85, 12.15], [29.85, 25.0], [30.0, 25.0], [30.0, 12.0], [20.0, 12.0]]]]} | 0.334875 | 11.0775 | 74 | PK.30.20.D | PK.30.20.D;PK.70.10.D | D_check;D_curb

# IfcLaborResource, inspector
LCS_Construction - Capacity: 1; RateKrwPerHour: 45000; Basis: ASSUMED; full retained shift
LCS_ResourcePool - Capacity: 1; CapacityBasis: Scenario assumption; per-task counts in IfcRelAssignsToProcess.QuantityInProcess; CostStatus: NOT_ESTIMATED

# IfcPavement (7)
In: Local synthetic site; not georeferenced
PredefinedType: FLEXIBLE; Material: Concrete blocks 200x200x60mm ASSUMED; Group: 10 포장·경계·지형
LCS_Provenance - Source: SYNTHETIC
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; TopPlane: z=0.015*(40-x)+0.018*y; DisplayOffset_m: 0.005; DisplayLayerThickness_m: 0.06; BlockModuleX_m: 0.2; BlockModuleY_m: 0.2; BlockThickness_m: 0.06; IndividualBlocksModelled: no
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 4; ClassificationVersion: R1-WBS2
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Kind | Zone | GeometryJSON | ElevationMetre | cover (m2) | blocks | subbase (m3) | sand_bedding (m3) | PrimaryWBS | WBSCodeList | LegacyTaskIds | ItemName | NurseryOrFacilitySpecification
walkway_A | 보행로 / 200×200 콘크리트블록 / walkway_A | PK.40.30.A 모래·콘크리트블록 포장 / A구역 (모래·콘크리트블록 포장) | walkway_A | walkway | A | {"type": "Polygon", "coordinates": [[[20.0, 40.0], [20.0, 38.0], [10.0, 38.0], [10.0, 25.0], [8.0, 25.0], [8.0, 40.0], [20.0, 40.0]]]} | 1.032 | 50 | 1250 | 7.5 | 1.5 | PK.40.30.A | PK.40.10.A;PK.40.20.A;PK.40.30.A;PK.70.10.A | A_check;A_finish;A_pavecheck;A_subbase | 보행로 블록포장 | 200×200mm / 유효폭 2m
walkway_B | 보행로 / 200×200 콘크리트블록 / walkway_B | PK.40.30.B 모래·콘크리트블록 포장 / B구역 (모래·콘크리트블록 포장) | walkway_B | walkway | B | {"type": "Polygon", "coordinates": [[[32.0, 40.0], [32.0, 25.0], [30.0, 25.0], [30.0, 38.0], [20.0, 38.0], [20.0, 40.0], [32.0, 40.0]]]} | 0.702 | 50 | 1250 | 7.5 | 1.5 | PK.40.30.B | PK.40.10.B;PK.40.20.B;PK.40.30.B;PK.70.10.B | B_check;B_finish;B_pavecheck;B_subbase | 보행로 블록포장 | 200×200mm / 유효폭 2m
walkway_C | 보행로 / 200×200 콘크리트블록 / walkway_C | PK.40.30.C 모래·콘크리트블록 포장 / C구역 (모래·콘크리트블록 포장) | walkway_C | walkway | C | {"type": "Polygon", "coordinates": [[[19.0, 0.0], [19.0, 10.0], [8.0, 10.0], [8.0, 25.0], [10.0, 25.0], [10.0, 12.0], [20.0, 12.0], [20.0, 0.0], [19.0, 0.0]]]} | 0.798 | 60 | 1500 | 9 | 1.8 | PK.40.30.C | PK.40.10.C;PK.40.20.C;PK.40.30.C;PK.70.10.C | C_check;C_finish;C_pavecheck;C_subbase | 보행로 블록포장 | 200×200mm / 유효폭 2m
walkway_D | 보행로 / 200×200 콘크리트블록 / walkway_D | PK.40.30.D 모래·콘크리트블록 포장 / D구역 (모래·콘크리트블록 포장) | walkway_D | walkway | D | {"type": "Polygon", "coordinates": [[[32.0, 10.0], [21.0, 10.0], [21.0, 0.0], [20.0, 0.0], [20.0, 12.0], [30.0, 12.0], [30.0, 25.0], [32.0, 25.0], [32.0, 10.0]]]} | 0.468 | 60 | 1500 | 9 | 1.8 | PK.40.30.D | PK.40.10.D;PK.40.20.D;PK.40.30.D;PK.70.10.D | D_check;D_finish;D_pavecheck;D_subbase | 보행로 블록포장 | 200×200mm / 유효폭 2m
plaza_A | 휴게포장 / 200×200 콘크리트블록 / plaza_A | PK.40.30.A 모래·콘크리트블록 포장 / A구역 (모래·콘크리트블록 포장) | plaza_A | plaza | A | {"type": "MultiPolygon", "coordinates": [[[[5.0, 31.0], [8.0, 31.0], [8.0, 27.0], [5.0, 27.0], [5.0, 31.0]]], [[[13.0, 43.0], [19.0, 43.0], [19.0, 40.0], [13.0, 40.0], [13.0, 43.0]]]]} | 1.107 | 30 | 750 | 4.5 | 0.9 | PK.40.30.A | PK.40.10.A;PK.40.20.A;PK.40.30.A;PK.70.10.A | A_check;A_finish;A_pavecheck;A_subbase | 휴게공간 블록포장 | 200×200mm
plaza_C | 휴게포장 / 200×200 콘크리트블록 / plaza_C | PK.40.30.C 모래·콘크리트블록 포장 / C구역 (모래·콘크리트블록 포장) | plaza_C | plaza | C | {"type": "MultiPolygon", "coordinates": [[[[16.0, 0.0], [16.0, 4.0], [19.0, 4.0], [19.0, 0.0], [16.0, 0.0]]], [[[9.0, 6.0], [9.0, 10.0], [15.0, 10.0], [15.0, 6.0], [9.0, 6.0]]]]} | 0.564 | 36 | 900 | 5.4 | 1.08 | PK.40.30.C | PK.40.10.C;PK.40.20.C;PK.40.30.C;PK.70.10.C | C_check;C_finish;C_pavecheck;C_subbase | 휴게공간 블록포장 | 200×200mm
plaza_D | 휴게포장 / 200×200 콘크리트블록 / plaza_D | PK.40.30.D 모래·콘크리트블록 포장 / D구역 (모래·콘크리트블록 포장) | plaza_D | plaza | D | {"type": "MultiPolygon", "coordinates": [[[[21.0, 0.0], [21.0, 4.0], [24.0, 4.0], [24.0, 0.0], [21.0, 0.0]]], [[[32.0, 12.0], [32.0, 22.0], [38.0, 22.0], [38.0, 12.0], [32.0, 12.0]]]]} | 0.381 | 72 | 1800 | 10.8 | 2.16 | PK.40.30.D | PK.40.10.D;PK.40.20.D;PK.40.30.D;PK.70.10.D | D_check;D_finish;D_pavecheck;D_subbase | 휴게공간 블록포장 | 200×200mm

# IfcPipeSegment (4)
In: Local synthetic site; not georeferenced
PredefinedType: RIGIDSEGMENT; Classification: PK.20.30.SITE 집수정·우수관 연계 시공 / 전체 (집수정·우수관 연계 시공); Material: Pipe material unspecified; Group: 40 배수시설; P2 우배수 DN200
LCS_Provenance - Kind: pipe; Source: SYNTHETIC
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; VerticalDatum: ASSUMED TBM100; IFC local z + 100m; NominalDiameter_m: 0.2; CenterlineDepth_m: 0.6; NominalCover_m: 0.49; InnerDiameter_m: 0.2; OutsideDiameterAssumed_m: 0.22; SectionMeaning: Hollow ID200 / OD220 assumed; material and structural class unspecified; HydraulicStatus: NOT_VALIDATED
LCS_WBS - InventoryRole: NEW; PrimaryWBS: PK.20.30.SITE; LinkedTaskCount: 4; ItemName: 우수관; NurseryOrFacilitySpecification: DN200 / 외경220mm (가정); ClassificationVersion: R1-WBS2
Name | Description | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | pipe_install (m) | UpstreamInvertLocalZ_m | DownstreamInvertLocalZ_m | UpstreamInvertAssumedLevel_m | DownstreamInvertAssumedLevel_m | SlopePercent | GeometryLength3D_m | WBSCodeList | LegacyTaskIds
PIPE_A | 우배수관 DN200 / PIPE_A | PIPE_A | A | {"type": "LineString", "coordinates": [[9.0, 39.0], [31.0, 39.0]]} | 1.167 | 22 | 0.467 | 0.137 | 100.467 | 100.137 | 1.5 | 22.0025 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.A | A_check;SITE_drainage;SITE_draincheck;SITE_survey
PIPE_B | 우배수관 DN200 / PIPE_B | PIPE_B | B | {"type": "LineString", "coordinates": [[31.0, 39.0], [31.0, 11.0]]} | 0.837 | 28 | 0.137 | -0.367 | 100.137 | 99.633 | 1.8 | 28.0045 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.B | B_check;SITE_drainage;SITE_draincheck;SITE_survey
PIPE_C | 우배수관 DN200 / PIPE_C | PIPE_C | C | {"type": "LineString", "coordinates": [[9.0, 11.0], [31.0, 11.0]]} | 0.663 | 22 | -0.037 | -0.367 | 99.963 | 99.633 | 1.5 | 22.0025 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.C | C_check;SITE_drainage;SITE_draincheck;SITE_survey
PIPE_D | 우배수관 DN200 / PIPE_D | PIPE_D | D | {"type": "LineString", "coordinates": [[31.0, 11.0], [31.0, 0.0]]} | 0.333 | 11 | -0.367 | -0.565 | 99.633 | 99.435 | 1.8 | 11.0018 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.D | D_check;SITE_drainage;SITE_draincheck;SITE_survey

# IfcTask: EXECUTABLE_TASK (62)
Status: PLANNED; IsMilestone: no
LCS_Construction - ScheduleBasis: PREDICTED_PUMSEM2026_CONDITIONAL
LCS_WBS - HierarchyLevel: 3; NodeRole: LEAF; QuantityBasis: PROJECT_WORKLOAD_NOT_RESOURCE_QUANTITY; ClassificationBasis: PROJECT_DEFINED_NOT_IFC_MANDATED_CODES; ClassificationVersion: R1-WBS2
LCS_WorkNorm - Source: 2026 user-provided standard work norms PDF; SmallWorkRule: 복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음
LCS_Specification - Edition: 2024; RevisionDate: 2024-12-10; Status: MAPPED_NOT_COMPLIANCE_VERIFIED; CheckedOn: 2026-09-25
Name | Description | Identification = WBSCode | LongDescription | WorkMethod | PredefinedType | Classification | TaskJSON | ParentWBSCode | LegacyTaskId | WorkZones | ScopeObjectIds | WorkQuantity | WorkQuantityUnit | Status | CalculationJSON | PlannedNetWorkHours | Planned8HourCrewDays | SetupHours | TravelAllowanceHours | ResourceBundleJSON | EquipmentRequirement | IncludedWork | PrimaryCode | Title | Clauses | RelatedCodes | ApplicationNote | SourceURL
관로·집수정 굴착 / A구역 | P2 작업 A_trench / 작업량 4.3625 m3 | PK.20.10.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / trench | CONSTRUCTION | PK.20.10.A 관로·집수정 굴착 / A구역 (관로·집수정 굴착); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "A_trench", "wbs_code": "PK.20.10.A", "zone_id": "A", "activity_type": "trench", "input_object_ids": ["ZONE_A"], "output_object_ids": [], "quantity": 4.3625, "unit": "m3", "predecessors": ["SITE_survey"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 4, "productivity_unit": "m3/crew_hour", "productivity_model_id": "trench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "20", "parent_wbs_code": "PK.20.10", "wbs_name": "관로·집수정 굴착 / A구역", "task_guid": "1awomNFVnRZwldlF77MUPX", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_survey": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.090625, "planned_8h_crew_days": 0.136328125, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.20.10 | A_trench | A | ["ZONE_A"] | 4.3625 | m3 | ASSUMED_NOT_VERIFIED | [] | 1.09062 | 0.136328 | 0.2 | 0.15 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.2.1 준비배수; 3.3.1 땅깎기 | KCS 34 50 65 | 관로·집수정 굴착의 토공 기준. 흙막이 등은 지반·굴착 상세 확정 후 추가 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
되메우기·다짐 / A구역 | P2 작업 A_backfill / 작업량 2.894361 m3 | PK.20.50.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / backfill | CONSTRUCTION | PK.20.50.A 되메우기·다짐 / A구역 (되메우기·다짐); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "A_backfill", "wbs_code": "PK.20.50.A", "zone_id": "A", "activity_type": "backfill", "input_object_ids": ["ZONE_A"], "output_object_ids": [], "quantity": 2.8943606533614172, "unit": "m3", "predecessors": ["SITE_draincheck"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 6, "productivity_unit": "m3/crew_hour", "productivity_model_id": "backfill_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "24", "parent_wbs_code": "PK.20.50", "wbs_name": "되메우기·다짐 / A구역", "task_guid": "3TE4OM_MnK6egz$zYtXsmN", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_draincheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.4823934422269029, "planned_8h_crew_days": 0.06029918027836286, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.20.50 | A_backfill | A | ["ZONE_A"] | 2.89436 | m3 | ASSUMED_NOT_VERIFIED | [] | 0.482393 | 0.0602992 | 0.2 | 0.15 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.3.3 흙쌓기; 3.6.3 다짐도 검사 | KCS 34 50 65 | 관로 검사 후 되메우기·다짐. 매설 완료 후 접속부 확인·승인도 필요하다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
휴게시설 기초 / A구역 | P2 작업 A_foundation / 작업량 0.461073 m3 | PK.30.10.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / foundation | CONSTRUCTION | PK.30.10.A 휴게시설 기초 / A구역 (휴게시설 기초); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "A_foundation", "wbs_code": "PK.30.10.A", "zone_id": "A", "activity_type": "foundation", "input_object_ids": ["BENCH03", "BENCH04", "BENCH05"], "output_object_ids": [], "quantity": 0.4610726281102533, "unit": "m3", "predecessors": ["A_backfill"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 1.5, "productivity_unit": "m3/crew_hour", "productivity_model_id": "foundation_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "30", "parent_wbs_code": "PK.30.10", "wbs_name": "휴게시설 기초 / A구역", "task_guid": "1BmVQr1c5M_gfXjzhM7L$0", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_backfill": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.3073817520735022, "planned_8h_crew_days": 0.03842271900918778, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.30.10 | A_foundation | A | ["ZONE_A"] | 0.461073 | m3 | ASSUMED_NOT_VERIFIED | [] | 0.307382 | 0.0384227 | 0.2 | 0.15 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 05 | 조경시설물공통 | 3.2.1 토공; 3.2.2 기초; 3.2.5 콘크리트 공사 | KCS 34 50 20 | 벤치·퍼걸러 기초. 콘크리트 강도·양생·앵커 상세는 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2005%3A2024-12-10
식재기반 정비 / A구역 | P2 작업 A_soil / 작업량 410.7 m2 | PK.50.20.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / soil | CONSTRUCTION | PK.50.20.A 식재기반 정비 / A구역 (식재기반 정비); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서) | {"task_id": "A_soil", "wbs_code": "PK.50.20.A", "zone_id": "A", "activity_type": "soil", "input_object_ids": ["green_A", "lawn_A"], "output_object_ids": ["shrub_A"], "quantity": 410.70000000000005, "unit": "m2", "predecessors": ["A_curb"], "lag": 0, "required_resource_bundle": {"excavator": 1, "crew_landscaper": 1, "crew_general": 2}, "productivity": 45, "productivity_unit": "m2/crew_hour", "productivity_model_id": "soil_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "32", "parent_wbs_code": "PK.50.20", "wbs_name": "식재기반 정비 / A구역", "task_guid": "3dyUbdsNrVCwHVzxa3$Rzk", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_curb": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 9.126666666666667, "planned_8h_crew_days": 1.1408333333333334, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.50.20 | A_soil | A | ["ZONE_A"] | 410.7 | m2 | ASSUMED_NOT_VERIFIED | [] | 9.12667 | 1.14083 | 0.2 | 0.15 | {"excavator": 1, "crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 30 10 | 식재기반 조성 | 2.1 토양 관련 재료; 3.1.1 일반식재기반 조성 | KCS 34 20 10; KCS 34 40 05 | 식재용 토양·유효토심·배수 기반 검토. 토양 시험 및 현장 적합성은 미확인이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2030%2010%3A2024-12-10
교목 식재(구덩이 포함) / A구역 | P2 작업 A_trees / 작업량 4 ea | PK.50.30.A | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / trees | INSTALLATION | PK.50.30.A 교목 식재(구덩이 포함) / A구역 (교목 식재(구덩이 포함)); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "A_trees", "wbs_code": "PK.50.30.A", "zone_id": "A", "activity_type": "trees", "input_object_ids": [], "output_object_ids": ["P2_D02", "P2_I04", "P2_I07", "P2_N02"], "quantity": 4, "unit": "ea", "predecessors": ["A_soil"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1, "excavator": 1}, "productivity": 1.6923076923076925, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 16, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "33", "parent_wbs_code": "PK.50.30", "wbs_name": "교목 식재(구덩이 포함) / A구역", "task_guid": "0So0jbh9rNau6qaei8hHvw", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"A_soil": 0}, "included_pit_volume_m3": 2.03875651885486, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152"], "norm_breakdown": [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 2, "daily_output": 12, "hours": 1.3333333333333333, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}], "norm_work_hours": 2.3636363636363633, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제", "planned_net_work_hours": 2.3636363636363633, "planned_8h_crew_days": 0.2954545454545454, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.50.30 | A_trees | A | ["ZONE_A"] | 4 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 2, "daily_output": 12, "hours": 1.3333333333333333, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}] | 2.36364 | 0.295455 | 0 | 0.15 | {"crew_landscaper": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.5 지주세우기; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 신규 교목의 굴착·식재·지주·관수. 규격·분 상태·식재시기를 함께 확인한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152; NetCrewHours: 2.36364
화강석 경계석 설치 / A구역 | P2 작업 A_curb / 작업량 62.0 m | PK.30.20.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / curb | INSTALLATION | PK.30.20.A 화강석 경계석 설치 / A구역 (화강석 경계석 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "A_curb", "wbs_code": "PK.30.20.A", "zone_id": "A", "activity_type": "curb", "input_object_ids": [], "output_object_ids": ["CURB_A"], "quantity": 62.0, "unit": "m", "predecessors": ["A_backfill", "A_foundation"], "lag": 0, "required_resource_bundle": {"crew_special": 3, "crew_general": 1, "excavator": 1}, "productivity": 16.25, "productivity_unit": "m/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "39", "parent_wbs_code": "PK.30.20", "wbs_name": "화강석 경계석 설치 / A구역", "task_guid": "3joyYSC8HKEPbgAZ4qajEA", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"A_backfill": 0, "A_foundation": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385"], "norm_breakdown": [{"rate_key": "CURB_A", "quantity": 62.0, "daily_output": 130, "hours": 3.8153846153846156, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 3.8153846153846156, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 3.8153846153846156, "planned_8h_crew_days": 0.47692307692307695, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.30.20 | A_curb | A | ["ZONE_A"] | 62 | m | 2026_NORM_CONDITIONAL | [{"rate_key": "CURB_A", "quantity": 62.0, "daily_output": 130, "hours": 3.8153846153846156, "status": "CONDITIONAL_SITE"}] | 3.81538 | 0.476923 | 0 | 0.15 | {"crew_special": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 25 | 조경포장경계 | 3.1.1 토공 및 기초; 3.1.2 경계블록 | KCS 34 60 05; KCS 34 50 05 | 화강석 경계석 선형·높이·기초·줄눈·뒤채움. 기초 콘크리트 물량과 강도 확보 대기는 현재 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2025%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385; NetCrewHours: 3.81538
쇄석 포장기층 / A구역 | P2 작업 A_subbase / 작업량 80.0 m2 | PK.40.10.A | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / subbase | CONSTRUCTION | PK.40.10.A 쇄석 포장기층 / A구역 (쇄석 포장기층); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "A_subbase", "wbs_code": "PK.40.10.A", "zone_id": "A", "activity_type": "subbase", "input_object_ids": ["plaza_A", "walkway_A"], "output_object_ids": [], "quantity": 80.0, "unit": "m2", "predecessors": ["A_curb", "A_trees"], "lag": 0, "required_resource_bundle": {"crew_paver": 2, "crew_special": 2, "crew_general": 1}, "productivity": 18, "productivity_unit": "m2/crew_hour", "productivity_model_id": "subbase_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "40", "parent_wbs_code": "PK.40.10", "wbs_name": "쇄석 포장기층 / A구역", "task_guid": "0f3W6sURTVEen7o62Sslid", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_curb": 0, "A_trees": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정.", "planned_net_work_hours": 4.444444444444445, "planned_8h_crew_days": 0.5555555555555556, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.40.10 | A_subbase | A | ["ZONE_A"] | 80 | m2 | ASSUMED_NOT_VERIFIED | [] | 4.44444 | 0.555556 | 0.2 | 0.15 | {"crew_paver": 2, "crew_special": 2, "crew_general": 1} | 기존 합성모델 장비 가정 | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. | KCS 34 60 05 | 조경포장공통 | 3.3.3 원지반 정지 및 다짐; 3.3.4 쇄석기층 | KCS 34 60 15 | 블록포장 하부의 쇄석기층. 두께·다짐도·계획고를 검측한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
포장 기층 검사 / A구역 | P2 작업 A_pavecheck / 작업량 1 ea | PK.40.20.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / pavecheck | INSPECTION | PK.40.20.A 포장 기층 검사 / A구역 (포장 기층 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "A_pavecheck", "wbs_code": "PK.40.20.A", "zone_id": "A", "activity_type": "pavecheck", "input_object_ids": ["plaza_A", "walkway_A"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["A_subbase"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 2, "productivity_unit": "ea/crew_hour", "productivity_model_id": "pavecheck_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "41", "parent_wbs_code": "PK.40.20", "wbs_name": "포장 기층 검사 / A구역", "task_guid": "1tCdFKdqzKCBAYvGGCw_gZ", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_subbase": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.5, "planned_8h_crew_days": 0.0625, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.40.20 | A_pavecheck | A | ["ZONE_A"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 0.5 | 0.0625 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 05 | 조경포장공통 | 3.4 시공허용오차; 3.6 현장품질관리 | KCS 34 60 15; KCS 34 10 10 | 포장 기층 검사. 시험·검측을 통과했다는 의미가 아닌 기준 연결이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
모래·콘크리트블록 포장 / A구역 | P2 작업 A_finish / 작업량 80.0 m2 | PK.40.30.A | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / finish | CONSTRUCTION | PK.40.30.A 모래·콘크리트블록 포장 / A구역 (모래·콘크리트블록 포장); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "A_finish", "wbs_code": "PK.40.30.A", "zone_id": "A", "activity_type": "finish", "input_object_ids": [], "output_object_ids": ["plaza_A", "walkway_A"], "quantity": 80.0, "unit": "m2", "predecessors": ["A_pavecheck"], "lag": 0, "required_resource_bundle": {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1}, "productivity": 37.5, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": true, "closes": "A", "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "42", "parent_wbs_code": "PK.40.30", "wbs_name": "모래·콘크리트블록 포장 / A구역", "task_guid": "3l7YMsKq9LKQ4fikZrT1Lj", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"A_pavecheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374"], "norm_breakdown": [{"rate_key": "PAVING_A", "quantity": 80.0, "daily_output": 300, "hours": 2.1333333333333333, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 2.1333333333333333, "equipment_requirement": "굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "깔기모래·블록 절단 및 설치·줄눈채움·후다짐", "planned_net_work_hours": 2.1333333333333333, "planned_8h_crew_days": 0.26666666666666666, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.40.30 | A_finish | A | ["ZONE_A"] | 80 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "PAVING_A", "quantity": 80.0, "daily_output": 300, "hours": 2.1333333333333333, "status": "CONDITIONAL_SITE"}] | 2.13333 | 0.266667 | 0 | 0.15 | {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1} | 굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대 | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 | KCS 34 60 15 | 친환경블록포장 | 2.1.1 소형고압블록; 3.2.2 소형고압블록포장 | KCS 34 60 05; KCS 34 60 25 | 200×200mm 콘크리트블록을 소형고압블록 계열로 잠정 매칭. 제품 KS·물성은 자재 승인 시 확정한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2015%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374; NetCrewHours: 2.13333
