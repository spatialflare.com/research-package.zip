Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 9

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-09-25T10:04:36
Written by: IfcOpenShell 0.8.5-1c5b825
Made in: IfcOpenShell 0.8.5-1c5b825

# IfcProject, 소공원 R1 · 식재·시설물·WBS 공정 통합
Description: User-revised R1 planting, no preserved trees; synthetic terrain and connected DN200 drainage. Concept detail; not field surveyed.
LCS_ModelDetail - SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; CoordinateSystem: Local Cartesian metres; SW origin; ModelStatus: R1_REVISED; SimulationRecomputed: no; DrainageConnectionsModelled: yes; HydraulicsValidated: no
LCS_WBS - ClassificationVersion: R1-WBS2; SchemaTarget: IFC4X3_ADD2; LeafTasks: 62; SummaryTasks: 30; WBSHierarchy: Project > Work section > Work package > Zone task; DesignGeometryChanged: no

# IfcBuildingElementProxy: access (5)
In: Local synthetic site; not georeferenced
PredefinedType: USERDEFINED; Classification: PK.70.20.SITE 임시동선 복구 / 전체 (임시동선 복구); Group: 90 공정·보호 표시
LCS_Provenance - Kind: access; Source: SYNTHETIC
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: NON_PHYSICAL_WORK_METADATA; Display: Curves only; no opaque area slab
LCS_WBS - InventoryRole: WORK_SCOPE; PrimaryWBS: PK.70.20.SITE; WBSCodeList: PK.70.20.SITE; LegacyTaskIds: RESTORE; LinkedTaskCount: 1; ItemName: 임시동선; ClassificationVersion: R1-WBS2; MappingNote: Reference and work-scope objects are excluded from installed-item totals
Name | Description | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre
ACCESS_trunk | 임시 장비동선 / ACCESS_trunk | ACCESS_trunk | SITE | {"type": "LineString", "coordinates": [[20.0, 0.0], [20.0, 25.0]]} | 0.3
ACCESS_A | 임시 장비동선 / ACCESS_A | ACCESS_A | A | {"type": "LineString", "coordinates": [[20.0, 25.0], [10.0, 35.0]]} | 0.75
ACCESS_B | 임시 장비동선 / ACCESS_B | ACCESS_B | B | {"type": "LineString", "coordinates": [[20.0, 25.0], [23.0, 34.0], [30.0, 35.0]]} | 0.867
ACCESS_C | 임시 장비동선 / ACCESS_C | ACCESS_C | C | {"type": "LineString", "coordinates": [[20.0, 25.0], [10.0, 15.0]]} | 0.75
ACCESS_D | 임시 장비동선 / ACCESS_D | ACCESS_D | D | {"type": "LineString", "coordinates": [[20.0, 25.0], [30.0, 15.0]]} | 0.75

# IfcBuildingElementProxy: context_road, CONTEXT_ROAD
In: Local synthetic site; not georeferenced
Description: 남측 도로 8m / 외부 현황 가정 / CONTEXT_ROAD; PredefinedType: USERDEFINED; Group: 80 외부 현황 가정
LCS_Provenance - ObjectId: CONTEXT_ROAD; Kind: context_road; Zone: CONTEXT; GeometryJSON: {"type": "Polygon", "coordinates": [[[45.0, -10.0], [45.0, -2.0], [-5.0, -2.0], [-5.0, -10.0], [45.0, -10.0]]]}; Source: SYNTHETIC; ElevationMetre: 0.192
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; TopPlane: z=0.015*(40-x)+0.018*y; DisplayOffset_m: -0.12; DisplayLayerThickness_m: 0.12
LCS_WBS - ObjectId: CONTEXT_ROAD; InventoryRole: REFERENCE; LinkedTaskCount: 0; ItemName: 남측 도로(가정); ClassificationVersion: R1-WBS2; MappingNote: Reference and work-scope objects are excluded from installed-item totals

# IfcBuildingElementProxy: context_sidewalk, CONTEXT_SIDEWALK
In: Local synthetic site; not georeferenced
Description: 남측 보도 2m / 외부 현황 가정 / CONTEXT_SIDEWALK; PredefinedType: USERDEFINED; Group: 80 외부 현황 가정
LCS_Provenance - ObjectId: CONTEXT_SIDEWALK; Kind: context_sidewalk; Zone: CONTEXT; GeometryJSON: {"type": "Polygon", "coordinates": [[[45.0, -2.0], [45.0, 0.0], [-5.0, 0.0], [-5.0, -2.0], [45.0, -2.0]]]}; Source: SYNTHETIC; ElevationMetre: 0.282
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; TopPlane: z=0.015*(40-x)+0.018*y; DisplayOffset_m: 0.005; DisplayLayerThickness_m: 0.04
LCS_WBS - ObjectId: CONTEXT_SIDEWALK; InventoryRole: REFERENCE; LinkedTaskCount: 0; ItemName: 남측 보도(가정); ClassificationVersion: R1-WBS2; MappingNote: Reference and work-scope objects are excluded from installed-item totals

# IfcBuildingElementProxy: pergola, PERGOLA01
In: Local synthetic site; not georeferenced
Description: 퍼걸러 / PERGOLA01; PredefinedType: USERDEFINED; Classification: PK.60.20.D 퍼걸러 설치 / D구역 (퍼걸러 설치); Material: Timber ASSUMED; Group: 30 휴게시설
LCS_Provenance - ObjectId: PERGOLA01; Kind: pergola; Zone: D; GeometryJSON: {"type": "Polygon", "coordinates": [[[37.0, 15.0], [37.0, 19.0], [33.0, 19.0], [33.0, 15.0], [37.0, 15.0]]]}; Source: SYNTHETIC; ElevationMetre: 0.381
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; FootprintX_m: 4; FootprintY_m: 4; MinimumClearHeight_m: 2.5; PostSection_m: 0.15; Roof: Open rafters; no waterproof roof; StructuralDesign: NOT_CALCULATED
LCS_WBS - ObjectId: PERGOLA01; InventoryRole: NEW; PrimaryWBS: PK.60.20.D; WBSCodeList: PK.30.10.D;PK.60.20.D;PK.70.10.D; LegacyTaskIds: D_check;D_foundation;D_pergola; LinkedTaskCount: 3; ItemName: 퍼걸러; NurseryOrFacilitySpecification: 4.0×4.0m; ClassificationVersion: R1-WBS2

# IfcBuildingElementProxy: zone (4)
In: Local synthetic site; not georeferenced
PredefinedType: USERDEFINED; Group: 90 공정·보호 표시
LCS_Provenance - Kind: zone; Source: SYNTHETIC
LCS_Quantities - topsoil: 75 m3
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: NON_PHYSICAL_WORK_METADATA; Display: Curves only; no opaque area slab
LCS_WBS - InventoryRole: WORK_SCOPE; ItemName: 공사구역; ClassificationVersion: R1-WBS2; MappingNote: Reference and work-scope objects are excluded from installed-item totals
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | grading (m3) | trench (m3) | backfill (m3) | tree_pits (m3) | foundations (m3) | PrimaryWBS | WBSCodeList | LegacyTaskIds | LinkedTaskCount
ZONE_A | 공정구역 / ZONE_A | PK.20.10.A 관로·집수정 굴착 / A구역 (관로·집수정 굴착) | ZONE_A | A | {"type": "Polygon", "coordinates": [[[20.0, 25.0], [20.0, 50.0], [0.0, 50.0], [0.0, 25.0], [20.0, 25.0]]]} | 1.125 | 48.9461 | 4.3625 | 2.89436 | 2.03876 | 0.461073 | PK.20.10.A | PK.20.10.A;PK.20.50.A;PK.30.10.A;PK.30.20.A;PK.40.10.A;PK.40.20.A;PK.40.30.A;PK.50.20.A;PK.50.30.A;PK.50.40.A;PK.50.50.A;PK.50.60.A;PK.60.10.A;PK.70.10.A | A_backfill;A_bench;A_check;A_curb;A_finish;A_foundation;A_mulch;A_pavecheck;A_shrubs;A_soil;A_subbase;A_trees;A_trench;A_turf | 14
ZONE_B | 공정구역 / ZONE_B | PK.20.10.B 관로·집수정 굴착 / B구역 (관로·집수정 굴착) | ZONE_B | B | {"type": "Polygon", "coordinates": [[[40.0, 25.0], [40.0, 50.0], [20.0, 50.0], [20.0, 25.0], [40.0, 25.0]]]} | 0.825 | 48.2295 | 8.75 | 6.09368 | 3.05813 | 0 | PK.20.10.B | PK.20.10.B;PK.20.50.B;PK.30.20.B;PK.40.10.B;PK.40.20.B;PK.40.30.B;PK.50.20.B;PK.50.30.B;PK.50.40.B;PK.50.50.B;PK.50.60.B;PK.70.10.B | B_backfill;B_check;B_curb;B_finish;B_mulch;B_pavecheck;B_shrubs;B_soil;B_subbase;B_trees;B_trench;B_turf | 12
ZONE_C | 공정구역 / ZONE_C | PK.20.10.C 관로·집수정 굴착 / C구역 (관로·집수정 굴착) | ZONE_C | C | {"type": "Polygon", "coordinates": [[[20.0, 0.0], [20.0, 25.0], [0.0, 25.0], [0.0, 0.0], [20.0, 0.0]]]} | 0.675 | 49.1797 | 4.3625 | 2.89436 | 1.01938 | 0.153691 | PK.20.10.C | PK.20.10.C;PK.20.50.C;PK.30.10.C;PK.30.20.C;PK.40.10.C;PK.40.20.C;PK.40.30.C;PK.50.20.C;PK.50.30.C;PK.50.40.C;PK.50.50.C;PK.50.60.C;PK.60.10.C;PK.70.10.C | C_backfill;C_bench;C_check;C_curb;C_finish;C_foundation;C_mulch;C_pavecheck;C_shrubs;C_soil;C_subbase;C_trees;C_trench;C_turf | 14
ZONE_D | 공정구역 / ZONE_D | PK.20.10.D 관로·집수정 굴착 / D구역 (관로·집수정 굴착) | ZONE_D | D | {"type": "Polygon", "coordinates": [[[40.0, 0.0], [40.0, 25.0], [20.0, 25.0], [20.0, 0.0], [40.0, 0.0]]]} | 0.375 | 47.3379 | 12.1625 | 8.58204 | 2.03876 | 2.0938 | PK.20.10.D | PK.20.10.D;PK.20.50.D;PK.30.10.D;PK.30.20.D;PK.40.10.D;PK.40.20.D;PK.40.30.D;PK.50.20.D;PK.50.30.D;PK.50.40.D;PK.50.50.D;PK.50.60.D;PK.60.10.D;PK.60.20.D;PK.70.10.D | D_backfill;D_bench;D_check;D_curb;D_finish;D_foundation;D_mulch;D_pavecheck;D_pergola;D_shrubs;D_soil;D_subbase;D_trees;D_trench;D_turf | 15

# IfcConstructionEquipmentResource (4)
LCS_Construction - Capacity: 1; Basis: ASSUMED; full retained shift
LCS_ResourcePool - Capacity: 1; CapacityBasis: Scenario assumption; per-task counts in IfcRelAssignsToProcess.QuantityInProcess; CostStatus: NOT_ESTIMATED
Name | RateKrwPerHour
excavator | 75000
plate_compactor | 0
truck | 45000
gate | 0

# IfcCrewResource (5)
LCS_Construction - Basis: ASSUMED; full retained shift
LCS_ResourcePool - CapacityBasis: Scenario assumption; per-task counts in IfcRelAssignsToProcess.QuantityInProcess; CostStatus: NOT_ESTIMATED
Name | LCS_Construction, Capacity = LCS_ResourcePool, Capacity | RateKrwPerHour
earth_crew | 1 | 90000
crew_landscaper | 3 | 0
crew_general | 4 | 0
crew_special | 3 | 0
crew_paver | 3 | 0

# IfcDistributionChamberElement (4)
In: Local synthetic site; not georeferenced
PredefinedType: SUMP; Classification: PK.20.30.SITE 집수정·우수관 연계 시공 / 전체 (집수정·우수관 연계 시공); Material: Concrete and metal grate ASSUMED; Group: 40 배수시설; P2 우배수 DN200
LCS_Provenance - Kind: chamber; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; VerticalDatum: ASSUMED TBM100; IFC local z + 100m; InternalWidth_m: 0.6; ExternalWidth_m: 0.8; Depth_m: 1; PipeInvertDepth_m: 0.7; SumpBelowInvert_m: 0.2; Connections: 240mm square concept wall openings; fixed IFC ports connected to pipes; Grate: Assumed flush open grate
LCS_WBS - InventoryRole: NEW; PrimaryWBS: PK.20.30.SITE; LinkedTaskCount: 4; ItemName: 집수정; NurseryOrFacilitySpecification: 내측600×600 / 깊이1000mm (가정); ClassificationVersion: R1-WBS2
Name | Description | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | InvertLocalZ_m | InvertAssumedLevel_m | WBSCodeList | LegacyTaskIds
CHAMBER_A | 집수정 / CHAMBER_A | CHAMBER_A | A | {"type": "Point", "coordinates": [9.0, 39.0]} | 1.167 | 0.467 | 100.467 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.A | A_check;SITE_drainage;SITE_draincheck;SITE_survey
CHAMBER_B | 집수정 / CHAMBER_B | CHAMBER_B | B | {"type": "Point", "coordinates": [31.0, 39.0]} | 0.837 | 0.137 | 100.137 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.B | B_check;SITE_drainage;SITE_draincheck;SITE_survey
CHAMBER_C | 집수정 / CHAMBER_C | CHAMBER_C | C | {"type": "Point", "coordinates": [9.0, 11.0]} | 0.663 | -0.037 | 99.963 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.C | C_check;SITE_drainage;SITE_draincheck;SITE_survey
CHAMBER_D | 집수정 / CHAMBER_D | CHAMBER_D | D | {"type": "Point", "coordinates": [31.0, 11.0]} | 0.333 | -0.367 | 99.633 | PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.10.D | D_check;SITE_drainage;SITE_draincheck;SITE_survey

# IfcDistributionPort (15)
PredefinedType: PIPE; SystemType: STORMWATER
Name | FlowDirection
PIPE_A:IN | SINK
CHAMBER_A:PIPE_A | SOURCE
PIPE_A:OUT | SOURCE
CHAMBER_B:PIPE_A | SINK
PIPE_B:IN | SINK
CHAMBER_B:PIPE_B | SOURCE
PIPE_B:OUT | SOURCE
CHAMBER_D:PIPE_B | SINK
PIPE_C:IN | SINK
CHAMBER_C:PIPE_C | SOURCE
PIPE_C:OUT | SOURCE
CHAMBER_D:PIPE_C | SINK
PIPE_D:IN | SINK
CHAMBER_D:PIPE_D | SOURCE
PIPE_D:OUT | SOURCE | LCS_ModelDetail - BoundaryCondition: OPEN_OUTLET_AT_SITE_EDGE; ExternalConnection: UNCONFIRMED; excluded from pipe quantities

# IfcDistributionSystem, P2 우배수 DN200
PredefinedType: STORMWATER

# IfcFurniture: bench (6)
In: Local synthetic site; not georeferenced
PredefinedType: USERDEFINED; Material: Timber and metal ASSUMED; Group: 30 휴게시설
LCS_Provenance - Kind: bench; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Length_m: 1.8; Width_m: 0.6; SeatHeight_m: 0.48; OverallHeight_m: 0.92
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 3; ItemName: 벤치; NurseryOrFacilitySpecification: 1.8×0.6m (가정); ClassificationVersion: R1-WBS2
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | Orientation | PrimaryWBS | WBSCodeList | LegacyTaskIds
BENCH01 | 벤치 / BENCH01 | PK.60.10.D 벤치 설치 / D구역 (벤치 설치) | BENCH01 | D | {"type": "Point", "coordinates": [35.0, 14.8]} | 0.3414 | Faces north | PK.60.10.D | PK.30.10.D;PK.60.10.D;PK.70.10.D | D_bench;D_check;D_foundation
BENCH02 | 벤치 / BENCH02 | PK.60.10.D 벤치 설치 / D구역 (벤치 설치) | BENCH02 | D | {"type": "Point", "coordinates": [35.0, 19.2]} | 0.4206 | Faces south | PK.60.10.D | PK.30.10.D;PK.60.10.D;PK.70.10.D | D_bench;D_check;D_foundation
BENCH03 | 벤치 / BENCH03 | PK.60.10.A 벤치 설치 / A구역 (벤치 설치) | BENCH03 | A | {"type": "Point", "coordinates": [5.6, 29.0]} | 1.038 | Faces east | PK.60.10.A | PK.30.10.A;PK.60.10.A;PK.70.10.A | A_bench;A_check;A_foundation
BENCH04 | 벤치 / BENCH04 | PK.60.10.A 벤치 설치 / A구역 (벤치 설치) | BENCH04 | A | {"type": "Point", "coordinates": [14.8, 42.0]} | 1.134 | Faces south | PK.60.10.A | PK.30.10.A;PK.60.10.A;PK.70.10.A | A_bench;A_check;A_foundation
BENCH05 | 벤치 / BENCH05 | PK.60.10.A 벤치 설치 / A구역 (벤치 설치) | BENCH05 | A | {"type": "Point", "coordinates": [17.4, 42.0]} | 1.095 | Faces south | PK.60.10.A | PK.30.10.A;PK.60.10.A;PK.70.10.A | A_bench;A_check;A_foundation
BENCH06 | 벤치 / BENCH06 | PK.60.10.C 벤치 설치 / C구역 (벤치 설치) | BENCH06 | C | {"type": "Point", "coordinates": [11.6, 7.0]} | 0.552 | Faces north | PK.60.10.C | PK.30.10.C;PK.60.10.C;PK.70.10.C | C_bench;C_check;C_foundation

# IfcGeographicElement (13)
In: Local synthetic site; not georeferenced
LCS_Provenance - Source: SYNTHETIC
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT
LCS_WBS - ClassificationVersion: R1-WBS2
Name | Description | PredefinedType | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Kind | Zone | GeometryJSON | ElevationMetre | cover (m2) | TopPlane | DisplayOffset_m | DisplayLayerThickness_m | QuantityBasis | InventoryRole | PrimaryWBS | WBSCodeList | LegacyTaskIds | LinkedTaskCount | ItemName | Group | MappingNote
lawn_A | 잔디마당 / lawn_A | VEGETATION | PK.50.50.A 평떼 잔디붙임 / A구역 (평떼 잔디붙임) | lawn_A | lawn | A | {"type": "MultiPolygon", "coordinates": [[[[20.0, 37.85], [20.0, 25.0], [10.15, 25.0], [10.15, 37.85], [20.0, 37.85]]], [[[20.0, 50.0], [20.0, 49.295884146341464], [19.546875, 49.33125], [18.890625, 49.368750000000006], [18.21875, 49.393750000000004], [17.53125, 49.40625], [16.828125, 49.40624999999999], [16.109375, 49.39375], [15.375, 49.36875], [14.625, 49.33125], [13.90625, 49.303125], [13.21875, 49.284375000000004], [12.5625, 49.275000000000006], [11.9375, 49.275000000000006], [11.34375, 49.284375000000004], [10.78125, 49.303125], [10.25, 49.33125], [9.75, 49.36875], [9.296875, 49.346875], [8.890625, 49.26562499999999], [8.53125, 49.125], [8.21875, 48.925000000000004], [7.953125, 48.665625000000006], [7.734375, 48.346875], [7.5625, 47.96875], [7.4375, 47.53125], [7.359375, 47.1125], [7.328125, 46.712500000000006], [7.34375, 46.331250000000004], [7.40625, 45.96875], [7.515625, 45.62499999999999], [7.671875, 45.3], [7.875, 44.99375], [8.125, 44.70625], [8.390625, 44.459375], [8.671875, 44.253125000000004], [8.96875, 44.087500000000006], [9.28125, 43.962500000000006], [9.609375, 43.878125000000004], [9.953125, 43.834375], [10.25156124648129, 43.83177990220451], [10.25, 43.8], [10.253611454995852, 43.726487144752824], [10.264411039697578, 43.6536822584879], [10.282294748200844, 43.58228649205915], [10.307090350616535, 43.51298742572618], [10.338559051738734, 43.4464524473805], [10.37639779077309, 43.3833223252353], [10.420242159977947, 43.32420503687726], [10.469669914110089, 43.26966991411009], [10.524205036877266, 43.22024215997794], [10.583322325235299, 43.17639779077309], [10.646452447380502, 43.13855905173873], [10.712987425726183, 43.10709035061653], [10.782286492059153, 43.08229474820084], [10.853682258487904, 43.064411039697575], [10.92648714475283, 43.05361145499585], [11.0, 43.05], [11.07351285524717, 43.05361145499585], [11.146317741512096, 43.064411039697575], [11.217713507940847, 43.08229474820084], [11.287012574273817, 43.10709035061653], [11.353547552619498, 43.13855905173873], [11.416677674764701, 43.17639779077309], [11.475794963122734, 43.22024215997794], [11.530330085889911, 43.26966991411009], [11.579757840022053, 43.32420503687726], [11.62360220922691, 43.3833223252353], [11.661440948261266, 43.4464524473805], [11.692909649383465, 43.51298742572618], [11.717705251799156, 43.58228649205915], [11.735588960302422, 43.6536822584879], [11.746388545004148, 43.726487144752824], [11.75, 43.8], [11.746388545004148, 43.87351285524717], [11.735588960302422, 43.9463177415121], [11.717705251799156, 44.01771350794085], [11.692909649383465, 44.087012574273814], [11.71630486423801, 44.02162732898318], [11.859375, 44.046875], [12.265625, 44.128125000000004], [12.6796875, 44.220312500000006], [13.1015625, 44.3234375], [13.53125, 44.4375], [13.96875, 44.5625], [14.4140625, 44.66875], [14.8671875, 44.756249999999994], [15.328125, 44.824999999999996], [15.796875, 44.875], [16.2734375, 44.90625000000001], [16.7578125, 44.91875], [17.25, 44.9125], [17.75, 44.8875], [18.2421875, 44.8390625], [18.7265625, 44.7671875], [19.203125, 44.671875], [19.671875, 44.553124999999994], [20.0, 44.45190677966101], [20.0, 40.15], [19.15, 40.15], [19.15, 43.15], [12.85, 43.15], [12.85, 40.15], [7.85, 40.15], [7.85, 31.15], [4.85, 31.15], [4.85, 26.85], [7.85, 26.85], [7.85, 25.0], [5.85, 25.0], [5.653124999999999, 25.1640625], [5.309374999999999, 25.3671875], [4.9312499999999995, 25.515625], [4.51875, 25.609375], [4.071875, 25.6484375], [3.5906249999999997, 25.6328125], [3.0749999999999997, 25.5625], [2.525, 25.4375], [2.0484375, 25.25], [1.6453125, 25.0], [0.0, 25.0], [0.0, 50.0], [20.0, 50.0]], [[3.6757949631227342, 25.920242159977946], [3.7303300858899107, 25.96966991411009], [3.779757840022053, 26.024205036877266], [3.823602209226909, 26.083322325235297], [3.8614409482612664, 26.1464524473805], [3.892909649383465, 26.212987425726183], [3.917705251799157, 26.282286492059153], [3.935588960302423, 26.353682258487904], [3.946388545004148, 26.42648714475283], [3.95, 26.5], [3.946388545004148, 26.57351285524717], [3.935588960302423, 26.646317741512096], [3.917705251799157, 26.717713507940847], [3.892909649383465, 26.787012574273817], [3.8614409482612664, 26.8535475526195], [3.823602209226909, 26.916677674764703], [3.779757840022053, 26.975794963122734], [3.7303300858899107, 27.03033008588991], [3.6757949631227342, 27.079757840022054], [3.6166776747647016, 27.12360220922691], [3.5535475526194986, 27.161440948261266], [3.487012574273818, 27.192909649383466], [3.4177135079408467, 27.217705251799156], [3.3463177415120966, 27.235588960302422], [3.27351285524717, 27.246388545004148], [3.2, 27.25], [3.1264871447528297, 27.246388545004148], [3.0536822584879038, 27.235588960302422], [2.982286492059153, 27.217705251799156], [2.9129874257261825, 27.192909649383466], [2.8464524473805017, 27.161440948261266], [2.7833223252352983, 27.12360220922691], [2.7242050368772657, 27.07975784002205], [2.6696699141100897, 27.03033008588991], [2.6202421599779475, 26.975794963122734], [2.576397790773091, 26.916677674764703], [2.538559051738734, 26.8535475526195], [2.507090350616535, 26.787012574273817], [2.4822947482008435, 26.717713507940847], [2.4644110396975774, 26.646317741512096], [2.4536114549958525, 26.57351285524717], [2.45, 26.5], [2.4536114549958525, 26.42648714475283], [2.4644110396975774, 26.353682258487904], [2.4822947482008435, 26.282286492059153], [2.507090350616535, 26.212987425726183], [2.538559051738734, 26.1464524473805], [2.576397790773091, 26.083322325235297], [2.6202421599779475, 26.024205036877266], [2.6696699141100897, 25.96966991411009], [2.724205036877266, 25.920242159977946], [2.7833223252352988, 25.87639779077309], [2.8464524473805017, 25.838559051738734], [2.912987425726183, 25.807090350616534], [2.9822864920591536, 25.782294748200844], [3.053682258487904, 25.764411039697578], [3.1264871447528297, 25.753611454995852], [3.2, 25.75], [3.2735128552471706, 25.753611454995852], [3.3463177415120966, 25.764411039697578], [3.4177135079408467, 25.782294748200844], [3.4870125742738174, 25.807090350616534], [3.5535475526194986, 25.838559051738734], [3.616677674764702, 25.87639779077309], [3.6757949631227342, 25.920242159977946]], [[0.6, 35.71875], [0.6437499999999999, 34.7859375], [0.73125, 33.982812499999994], [0.8624999999999998, 33.309374999999996], [1.0374999999999996, 32.765625], [1.2562499999999996, 32.3515625], [1.5187499999999998, 32.067187499999996], [1.8249999999999997, 31.912499999999998], [2.175, 31.887500000000003], [2.5265625, 31.878125000000004], [2.8796874999999997, 31.884375000000002], [3.234375, 31.90625], [3.5906249999999997, 31.943749999999998], [3.9484375, 31.996874999999996], [4.3078125, 32.065625000000004], [4.668749999999999, 32.150000000000006], [5.03125, 32.25], [5.365625, 32.38125], [5.671874999999999, 32.54375000000001], [5.949999999999999, 32.73750000000001], [6.199999999999999, 32.962500000000006], [6.421874999999999, 33.21875], [6.615625, 33.506249999999994], [6.78125, 33.824999999999996], [6.91875, 34.175000000000004], [7.0328125, 34.5296875], [7.1234375000000005, 34.889062499999994], [7.190625000000001, 35.253125], [7.234375, 35.621874999999996], [7.2546875, 35.9953125], [7.2515625, 36.3734375], [7.225, 36.75625], [7.175, 37.143750000000004], [7.125, 37.534375000000004], [7.074999999999999, 37.928125], [7.025, 38.325], [6.975, 38.725], [6.925000000000001, 39.128125], [6.875, 39.534375], [6.825, 39.943749999999994], [6.775, 40.35625], [6.68125, 40.7359375], [6.543749999999999, 41.082812499999996], [6.362499999999999, 41.396874999999994], [6.137499999999999, 41.678124999999994], [5.8687499999999995, 41.926562499999996], [5.5562499999999995, 42.1421875], [5.199999999999999, 42.325], [4.8, 42.475], [4.40625, 42.5671875], [4.018749999999999, 42.60156250000001], [3.6374999999999993, 42.578125], [3.2624999999999997, 42.496875], [2.89375, 42.357812499999994], [2.5312499999999996, 42.1609375], [2.175, 41.90625], [1.8249999999999997, 41.59375], [1.5187499999999998, 41.1875], [1.2562499999999996, 40.6875], [1.0374999999999996, 40.09375], [0.8624999999999998, 39.40625], [0.73125, 38.625], [0.6437499999999999, 37.75], [0.6, 36.78125], [0.6, 35.71875]]]]} | 0.939525 | 286.004 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Net area; waste not included | NEW | PK.50.50.A | PK.50.20.A;PK.50.50.A;PK.70.10.A | A_check;A_soil;A_turf | 3 | 잔디 | 20 수목·녹지 | LCS_ModelDetail - SodModuleX_m: 0.3; SodModuleY_m: 0.3; SodMethod: Flat sod full coverage; NetSodEquivalent: 3177.82; LCS_WBS - NurseryOrFacilitySpecification: 평떼 300×300mm / 전면 붙임
lawn_B | 잔디마당 / lawn_B | VEGETATION | PK.50.50.B 평떼 잔디붙임 / B구역 (평떼 잔디붙임) | lawn_B | lawn | B | {"type": "MultiPolygon", "coordinates": [[[[20.0, 25.0], [20.0, 37.85], [29.85, 37.85], [29.85, 25.0], [20.0, 25.0]], [[27.53033008588991, 30.46966991411009], [27.579757840022054, 30.524205036877266], [27.62360220922691, 30.583322325235297], [27.661440948261266, 30.6464524473805], [27.692909649383466, 30.712987425726183], [27.717705251799156, 30.782286492059153], [27.735588960302422, 30.853682258487904], [27.746388545004148, 30.92648714475283], [27.75, 31.0], [27.746388545004148, 31.07351285524717], [27.735588960302422, 31.146317741512096], [27.717705251799156, 31.217713507940847], [27.692909649383466, 31.287012574273817], [27.661440948261266, 31.3535475526195], [27.62360220922691, 31.416677674764703], [27.57975784002205, 31.475794963122734], [27.53033008588991, 31.53033008588991], [27.475794963122734, 31.579757840022054], [27.416677674764703, 31.62360220922691], [27.3535475526195, 31.661440948261266], [27.287012574273817, 31.692909649383466], [27.217713507940847, 31.717705251799156], [27.146317741512096, 31.735588960302422], [27.07351285524717, 31.746388545004148], [27.0, 31.75], [26.92648714475283, 31.746388545004148], [26.853682258487904, 31.735588960302422], [26.782286492059153, 31.717705251799156], [26.712987425726183, 31.692909649383466], [26.6464524473805, 31.661440948261266], [26.583322325235297, 31.62360220922691], [26.524205036877266, 31.57975784002205], [26.46966991411009, 31.53033008588991], [26.420242159977946, 31.475794963122734], [26.37639779077309, 31.416677674764703], [26.338559051738734, 31.3535475526195], [26.307090350616534, 31.287012574273817], [26.282294748200844, 31.217713507940847], [26.264411039697578, 31.146317741512096], [26.253611454995852, 31.07351285524717], [26.25, 31.0], [26.253611454995852, 30.92648714475283], [26.264411039697578, 30.853682258487904], [26.282294748200844, 30.782286492059153], [26.307090350616534, 30.712987425726183], [26.338559051738734, 30.6464524473805], [26.37639779077309, 30.583322325235297], [26.420242159977946, 30.524205036877266], [26.46966991411009, 30.46966991411009], [26.524205036877266, 30.420242159977946], [26.583322325235297, 30.37639779077309], [26.6464524473805, 30.338559051738734], [26.712987425726183, 30.307090350616534], [26.782286492059153, 30.282294748200844], [26.853682258487904, 30.264411039697578], [26.92648714475283, 30.253611454995852], [27.0, 30.25], [27.07351285524717, 30.253611454995852], [27.146317741512096, 30.264411039697578], [27.217713507940847, 30.282294748200844], [27.287012574273817, 30.307090350616534], [27.3535475526195, 30.338559051738734], [27.416677674764703, 30.37639779077309], [27.475794963122734, 30.420242159977946], [27.53033008588991, 30.46966991411009]]], [[[40.0, 25.0], [38.7578125, 25.0], [38.810937499999994, 25.049999999999997], [39.028124999999996, 25.3375], [39.196875, 25.662499999999998], [39.3171875, 26.025], [39.389062499999994, 26.424999999999997], [39.412499999999994, 26.862499999999997], [39.3875, 27.337500000000002], [39.36875, 27.831250000000004], [39.356249999999996, 28.343750000000004], [39.349999999999994, 28.875000000000004], [39.349999999999994, 29.424999999999997], [39.356249999999996, 29.99375], [39.36875, 30.58125], [39.3875, 31.1875], [39.412499999999994, 31.8125], [39.4296875, 32.4578125], [39.439062500000006, 33.123437499999994], [39.440625000000004, 33.809375], [39.434374999999996, 34.515625], [39.420312499999994, 35.2421875], [39.3984375, 35.9890625], [39.368750000000006, 36.756249999999994], [39.33125, 37.54375], [39.2640625, 38.25], [39.167187500000004, 38.87499999999999], [39.040625000000006, 39.41874999999999], [38.884375000000006, 39.881249999999994], [38.698437500000004, 40.262499999999996], [38.4828125, 40.5625], [38.2375, 40.78125], [37.962500000000006, 40.918749999999996], [37.659375, 41.014062499999994], [37.328125, 41.0671875], [36.96875, 41.078125], [36.58125, 41.046875], [36.165625000000006, 40.9734375], [35.721875, 40.857812499999994], [35.25, 40.699999999999996], [34.75, 40.5], [34.30625, 40.265625], [33.91875, 39.996874999999996], [33.587500000000006, 39.693749999999994], [33.3125, 39.35624999999999], [33.09375, 38.98437499999999], [32.93124999999999, 38.578125], [32.824999999999996, 38.1375], [32.775, 37.662499999999994], [32.740625, 37.184375], [32.721875000000004, 36.703125], [32.71875, 36.21875], [32.73125, 35.73125], [32.759375, 35.240624999999994], [32.803125, 34.746875], [32.862500000000004, 34.25], [32.9375, 33.75], [32.995312500000004, 33.234375], [33.0359375, 32.703125], [33.059375, 32.15625], [33.065625000000004, 31.59375], [33.0546875, 31.015625], [33.02814616947982, 30.455308022351655], [33.1750557105545, 30.543362212609622], [33.33030399336109, 30.616789181894752], [33.49200181480469, 30.674645587531366], [33.65859193647177, 30.716374240705655], [33.82847000442327, 30.741573271676344], [34.0, 30.75], [34.17152999557673, 30.741573271676344], [34.34140806352823, 30.716374240705655], [34.507998185195305, 30.674645587531366], [34.66969600663891, 30.616789181894752], [34.8249442894455, 30.543362212609622], [34.9722479077843, 30.455071821529454], [35.11018824728638, 30.35276829338479], [35.23743686707646, 30.237436867076458], [35.35276829338479, 30.11018824728638], [35.45507182152945, 29.972247907784304], [35.54336221260962, 29.824944289445497], [35.61678918189475, 29.669696006638908], [35.674645587531366, 29.50799818519531], [35.716374240705655, 29.341408063528224], [35.741573271676344, 29.17152999557673], [35.75, 29.0], [35.741573271676344, 28.82847000442327], [35.716374240705655, 28.658591936471776], [35.674645587531366, 28.49200181480469], [35.61678918189475, 28.330303993361092], [35.54336221260962, 28.175055710554503], [35.45507182152945, 28.027752092215696], [35.35276829338479, 27.88981175271362], [35.23743686707646, 27.762563132923542], [35.11018824728638, 27.64723170661521], [34.97224790778431, 27.544928178470546], [34.8249442894455, 27.456637787390378], [34.66969600663891, 27.383210818105248], [34.50799818519531, 27.325354412468634], [34.34140806352823, 27.283625759294345], [34.17152999557673, 27.258426728323656], [34.0, 27.25], [33.82847000442327, 27.258426728323656], [33.65859193647177, 27.283625759294345], [33.49200181480469, 27.325354412468634], [33.33030399336109, 27.383210818105248], [33.1750557105545, 27.456637787390378], [33.0277520922157, 27.544928178470546], [32.88981175271362, 27.64723170661521], [32.838366219240186, 27.693859220237535], [32.834375, 27.5], [32.840625, 27.0], [32.8640625, 26.53125], [32.9046875, 26.09375], [32.9625, 25.6875], [33.0375, 25.3125], [33.148054245283014, 25.0], [32.15, 25.0], [32.15, 40.15], [20.0, 40.15], [20.0, 44.45190677966101], [20.1328125, 44.410937499999996], [20.5859375, 44.2453125], [21.03125, 44.05625], [21.46875, 43.84375], [21.9296875, 43.6640625], [22.4140625, 43.517187500000006], [22.921875, 43.403125], [23.453125, 43.321875000000006], [24.0078125, 43.27343750000001], [24.5859375, 43.25781250000001], [25.1875, 43.275000000000006], [25.8125, 43.324999999999996], [26.40625, 43.39375], [26.96875, 43.481249999999996], [27.5, 43.5875], [28.0, 43.7125], [28.46875, 43.856249999999996], [28.90625, 44.01875], [29.3125, 44.199999999999996], [29.6875, 44.400000000000006], [30.0625, 44.58906250000001], [30.4375, 44.767187500000006], [30.8125, 44.934375], [31.1875, 45.090625], [31.5625, 45.235937500000006], [31.9375, 45.37031250000001], [32.3125, 45.493750000000006], [32.6875, 45.606249999999996], [33.0125, 45.75781249999999], [33.287499999999994, 45.9484375], [33.5125, 46.178125], [33.6875, 46.446875], [33.8125, 46.7546875], [33.8875, 47.10156250000001], [33.912499999999994, 47.487500000000004], [33.8875, 47.912499999999994], [33.775, 48.28593749999999], [33.574999999999996, 48.607812499999994], [33.287499999999994, 48.878125], [32.912499999999994, 49.096875], [32.449999999999996, 49.264062499999994], [31.899999999999995, 49.37968749999999], [31.262499999999996, 49.443749999999994], [30.537499999999998, 49.456250000000004], [29.824999999999996, 49.45937500000001], [29.124999999999996, 49.45312500000001], [28.437499999999996, 49.43750000000001], [27.762500000000003, 49.412499999999994], [27.1, 49.378125], [26.45, 49.334375], [25.8125, 49.28125], [25.1875, 49.21875], [24.5625, 49.171875], [23.9375, 49.140625], [23.3125, 49.125], [22.6875, 49.125], [22.0625, 49.140625], [21.4375, 49.171875], [20.8125, 49.21875], [20.1875, 49.28125], [20.0, 49.295884146341464], [20.0, 50.0], [40.0, 50.0], [40.0, 25.0]], [[26.975794963122734, 41.920242159977946], [27.03033008588991, 41.96966991411009], [27.079757840022054, 42.02420503687726], [27.12360220922691, 42.0833223252353], [27.161440948261266, 42.146452447380504], [27.192909649383466, 42.21298742572618], [27.217705251799156, 42.28228649205915], [27.235588960302422, 42.3536822584879], [27.246388545004148, 42.42648714475283], [27.25, 42.5], [27.246388545004148, 42.57351285524717], [27.235588960302422, 42.6463177415121], [27.217705251799156, 42.71771350794085], [27.192909649383466, 42.78701257427382], [27.161440948261266, 42.853547552619496], [27.12360220922691, 42.9166776747647], [27.07975784002205, 42.97579496312274], [27.03033008588991, 43.03033008588991], [26.975794963122734, 43.079757840022054], [26.916677674764703, 43.12360220922691], [26.8535475526195, 43.161440948261266], [26.787012574273817, 43.192909649383466], [26.717713507940847, 43.21770525179916], [26.646317741512096, 43.23558896030242], [26.57351285524717, 43.246388545004145], [26.5, 43.25], [26.42648714475283, 43.246388545004145], [26.353682258487904, 43.23558896030242], [26.282286492059153, 43.21770525179916], [26.212987425726183, 43.192909649383466], [26.1464524473805, 43.161440948261266], [26.083322325235297, 43.12360220922691], [26.024205036877266, 43.079757840022054], [25.96966991411009, 43.03033008588991], [25.920242159977946, 42.97579496312273], [25.87639779077309, 42.9166776747647], [25.838559051738734, 42.853547552619496], [25.807090350616534, 42.78701257427382], [25.782294748200844, 42.71771350794085], [25.764411039697578, 42.6463177415121], [25.753611454995852, 42.57351285524717], [25.75, 42.5], [25.753611454995852, 42.42648714475283], [25.764411039697578, 42.3536822584879], [25.782294748200844, 42.28228649205915], [25.807090350616534, 42.21298742572618], [25.838559051738734, 42.146452447380504], [25.87639779077309, 42.0833223252353], [25.920242159977946, 42.02420503687726], [25.96966991411009, 41.96966991411009], [26.024205036877266, 41.920242159977946], [26.083322325235297, 41.87639779077309], [26.1464524473805, 41.838559051738734], [26.212987425726183, 41.807090350616534], [26.282286492059153, 41.78229474820084], [26.353682258487904, 41.76441103969758], [26.42648714475283, 41.753611454995855], [26.5, 41.75], [26.57351285524717, 41.753611454995855], [26.646317741512096, 41.76441103969758], [26.717713507940847, 41.78229474820084], [26.787012574273817, 41.807090350616534], [26.8535475526195, 41.838559051738734], [26.916677674764703, 41.87639779077309], [26.975794963122734, 41.920242159977946]], [[37.47579496312274, 46.420242159977946], [37.53033008588991, 46.46966991411009], [37.579757840022054, 46.52420503687726], [37.62360220922691, 46.5833223252353], [37.661440948261266, 46.646452447380504], [37.692909649383466, 46.71298742572618], [37.71770525179916, 46.78228649205915], [37.73558896030242, 46.8536822584879], [37.746388545004145, 46.92648714475283], [37.75, 47.0], [37.746388545004145, 47.07351285524717], [37.73558896030242, 47.1463177415121], [37.71770525179916, 47.21771350794085], [37.692909649383466, 47.28701257427382], [37.661440948261266, 47.353547552619496], [37.62360220922691, 47.4166776747647], [37.579757840022054, 47.47579496312274], [37.53033008588991, 47.53033008588991], [37.47579496312274, 47.579757840022054], [37.4166776747647, 47.62360220922691], [37.353547552619496, 47.661440948261266], [37.28701257427382, 47.692909649383466], [37.21771350794084, 47.71770525179916], [37.1463177415121, 47.73558896030242], [37.07351285524717, 47.746388545004145], [37.0, 47.75], [36.92648714475283, 47.746388545004145], [36.8536822584879, 47.73558896030242], [36.78228649205915, 47.71770525179916], [36.71298742572618, 47.692909649383466], [36.646452447380504, 47.661440948261266], [36.5833223252353, 47.62360220922691], [36.52420503687726, 47.579757840022054], [36.46966991411009, 47.53033008588991], [36.420242159977946, 47.47579496312273], [36.37639779077309, 47.4166776747647], [36.338559051738734, 47.353547552619496], [36.307090350616534, 47.28701257427382], [36.28229474820084, 47.21771350794085], [36.26441103969758, 47.1463177415121], [36.253611454995855, 47.07351285524717], [36.25, 47.0], [36.253611454995855, 46.92648714475283], [36.26441103969758, 46.8536822584879], [36.28229474820084, 46.78228649205915], [36.307090350616534, 46.71298742572618], [36.338559051738734, 46.646452447380504], [36.37639779077309, 46.5833223252353], [36.420242159977946, 46.52420503687726], [36.46966991411009, 46.46966991411009], [36.52420503687726, 46.420242159977946], [36.5833223252353, 46.37639779077309], [36.646452447380504, 46.338559051738734], [36.71298742572618, 46.307090350616534], [36.78228649205915, 46.28229474820084], [36.8536822584879, 46.26441103969758], [36.92648714475283, 46.253611454995855], [37.0, 46.25], [37.07351285524717, 46.253611454995855], [37.1463177415121, 46.26441103969758], [37.21771350794085, 46.28229474820084], [37.28701257427382, 46.307090350616534], [37.353547552619496, 46.338559051738734], [37.4166776747647, 46.37639779077309], [37.47579496312274, 46.420242159977946]]]]} | 0.818045 | 275.214 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Net area; waste not included | NEW | PK.50.50.B | PK.50.20.B;PK.50.50.B;PK.70.10.B | B_check;B_soil;B_turf | 3 | 잔디 | 20 수목·녹지 | LCS_ModelDetail - SodModuleX_m: 0.3; SodModuleY_m: 0.3; SodMethod: Flat sod full coverage; NetSodEquivalent: 3057.94; LCS_WBS - NurseryOrFacilitySpecification: 평떼 300×300mm / 전면 붙임
lawn_C | 잔디마당 / lawn_C | VEGETATION | PK.50.50.C 평떼 잔디붙임 / C구역 (평떼 잔디붙임) | lawn_C | lawn | C | {"type": "MultiPolygon", "coordinates": [[[[1.6453125, 25.0], [1.3156249999999998, 24.6875], [1.059375, 24.3125], [0.8765624999999999, 23.875], [0.7671875, 23.375], [0.7312500000000001, 22.8125], [0.7687499999999999, 22.1875], [0.7953125, 21.53125], [0.8109375000000001, 20.84375], [0.815625, 20.125], [0.8093750000000001, 19.375], [0.7921875, 18.59375], [0.7640625000000001, 17.78125], [0.7250000000000001, 16.9375], [0.6749999999999999, 16.0625], [0.6703124999999999, 15.2890625], [0.7109374999999999, 14.6171875], [0.7968749999999999, 14.046875], [0.9281250000000001, 13.578125], [1.1046875, 13.2109375], [1.3265625, 12.9453125], [1.59375, 12.78125], [1.90625, 12.71875], [2.234375, 12.6875], [2.578125, 12.6875], [2.9375, 12.71875], [3.3125, 12.78125], [3.703125, 12.875], [4.109375, 13.0], [4.53125, 13.15625], [4.96875, 13.34375], [5.365625, 13.5546875], [5.721875000000001, 13.7890625], [6.0375000000000005, 14.046875], [6.3125, 14.328125], [6.546874999999999, 14.6328125], [6.740625, 14.9609375], [6.89375, 15.3125], [7.00625, 15.6875], [7.096875000000001, 16.0625], [7.165625, 16.4375], [7.2125, 16.8125], [7.237500000000001, 17.1875], [7.240625000000001, 17.5625], [7.221875000000001, 17.9375], [7.18125, 18.3125], [7.11875, 18.6875], [7.068750000000001, 19.0703125], [7.03125, 19.4609375], [7.0062500000000005, 19.859375], [6.99375, 20.265625], [6.99375, 20.6796875], [7.0062500000000005, 21.1015625], [7.03125, 21.53125], [7.0687500000000005, 21.96875], [7.067187500000001, 22.390625], [7.026562499999999, 22.796875], [6.9468749999999995, 23.1875], [6.828125, 23.5625], [6.6703125000000005, 23.921875], [6.473437500000001, 24.265625], [6.237500000000001, 24.59375], [5.9624999999999995, 24.90625], [5.85, 25.0], [7.85, 25.0], [7.85, 9.85], [8.85, 9.85], [8.85, 5.85], [15.15, 5.85], [15.15, 9.85], [18.85, 9.85], [18.85, 4.15], [15.85, 4.15], [15.85, 0.0], [0.0, 0.0], [0.0, 25.0], [1.6453125, 25.0]], [[12.5625, 1.0578125], [13.1875, 1.05625], [13.8125, 1.0437500000000002], [14.3625, 1.0765625], [14.837499999999999, 1.1546875], [15.237499999999999, 1.278125], [15.5, 1.414423076923077], [15.5, 2.45], [15.5, 4.284778225806451], [15.4125, 4.3687499999999995], [15.1875, 4.53125], [14.9296875, 4.668749999999999], [14.639062500000001, 4.78125], [14.315625, 4.8687499999999995], [13.959375000000001, 4.9312499999999995], [13.570312500000002, 4.96875], [13.148437500000002, 4.981249999999999], [12.693750000000001, 4.96875], [12.206249999999999, 4.9312499999999995], [11.724999999999998, 4.9140625], [11.249999999999998, 4.917187500000001], [10.781249999999998, 4.940625000000001], [10.318750000000001, 4.984375], [9.8625, 5.0484374999999995], [9.4125, 5.1328125], [8.96875, 5.2375], [8.53125, 5.3625], [8.0703125, 5.465624999999999], [7.5859375, 5.546875], [7.501135760180413, 5.556790280348136], [7.475794963122734, 5.579757840022053], [7.416677674764701, 5.62360220922691], [7.353547552619498, 5.661440948261267], [7.287012574273818, 5.6929096493834646], [7.2177135079408465, 5.717705251799156], [7.146317741512096, 5.735588960302422], [7.07351285524717, 5.746388545004148], [7.0, 5.75], [6.92648714475283, 5.746388545004148], [6.853682258487903, 5.735588960302422], [6.7822864920591535, 5.717705251799156], [6.712987425726182, 5.6929096493834646], [6.646452447380502, 5.661440948261266], [6.583322325235298, 5.623602209226909], [6.6095550895899, 5.639325523087771], [6.546875, 5.643749999999999], [5.9921875, 5.659374999999999], [5.4140625, 5.653124999999999], [4.8125, 5.625], [4.1875, 5.575], [3.6171875, 5.4984375000000005], [3.1015625, 5.395312500000001], [2.640625, 5.265625000000001], [2.234375, 5.109375000000001], [1.8828125, 4.926562500000001], [1.5859375, 4.7171875000000005], [1.34375, 4.481250000000001], [1.15625, 4.21875], [0.9921875, 3.953125], [0.8515625, 3.6843749999999997], [0.734375, 3.4124999999999996], [0.7002724795640328, 3.312465940054496], [0.640625, 3.1374999999999993], [0.5703125, 2.8593749999999996], [0.5234375, 2.5781249999999996], [0.5, 2.2937499999999993], [0.5, 2.0062499999999996], [0.5859375, 1.7468749999999997], [0.7578125, 1.5156249999999998], [1.015625, 1.3124999999999998], [1.359375, 1.1375000000000002], [1.7890625, 0.9906250000000001], [2.3046875, 0.871875], [2.90625, 0.78125], [3.59375, 0.71875], [4.2734375, 0.6734375], [4.9453125, 0.6453125], [5.609375, 0.6343749999999999], [6.265625, 0.640625], [6.9140625, 0.6640625], [7.5546875, 0.7046875000000001], [8.1875, 0.7625000000000001], [8.8125, 0.8375], [9.4375, 0.9015625], [10.0625, 0.9546875], [10.6875, 0.9968750000000001], [11.3125, 1.0281250000000002], [11.9375, 1.0484375000000001], [12.5625, 1.0578125]], [[5.475794963122734, 11.420242159977947], [5.5303300858899105, 11.469669914110089], [5.579757840022053, 11.524205036877266], [5.623602209226909, 11.583322325235299], [5.661440948261267, 11.646452447380502], [5.6929096493834646, 11.712987425726183], [5.717705251799156, 11.782286492059153], [5.735588960302422, 11.853682258487904], [5.746388545004148, 11.92648714475283], [5.75, 12.0], [5.746388545004148, 12.07351285524717], [5.735588960302422, 12.146317741512096], [5.717705251799156, 12.217713507940847], [5.6929096493834646, 12.287012574273819], [5.661440948261266, 12.3535475526195], [5.623602209226909, 12.416677674764701], [5.579757840022053, 12.475794963122734], [5.5303300858899105, 12.530330085889911], [5.475794963122734, 12.579757840022053], [5.416677674764701, 12.62360220922691], [5.353547552619498, 12.661440948261266], [5.287012574273818, 12.692909649383465], [5.2177135079408465, 12.717705251799156], [5.146317741512096, 12.735588960302422], [5.07351285524717, 12.746388545004148], [5.0, 12.75], [4.92648714475283, 12.746388545004148], [4.853682258487903, 12.735588960302422], [4.7822864920591535, 12.717705251799156], [4.712987425726182, 12.692909649383465], [4.646452447380502, 12.661440948261266], [4.583322325235298, 12.62360220922691], [4.524205036877266, 12.579757840022053], [4.4696699141100895, 12.530330085889911], [4.420242159977947, 12.475794963122734], [4.37639779077309, 12.416677674764701], [4.338559051738733, 12.353547552619498], [4.307090350616535, 12.287012574273817], [4.282294748200844, 12.217713507940847], [4.264411039697578, 12.146317741512096], [4.253611454995852, 12.07351285524717], [4.25, 12.0], [4.253611454995852, 11.92648714475283], [4.264411039697578, 11.853682258487904], [4.282294748200844, 11.782286492059153], [4.3070903506165354, 11.712987425726183], [4.338559051738734, 11.646452447380502], [4.376397790773091, 11.583322325235299], [4.420242159977947, 11.524205036877266], [4.4696699141100895, 11.469669914110089], [4.524205036877266, 11.420242159977947], [4.583322325235298, 11.37639779077309], [4.646452447380502, 11.338559051738734], [4.712987425726182, 11.307090350616535], [4.7822864920591535, 11.282294748200844], [4.853682258487904, 11.264411039697578], [4.926487144752829, 11.253611454995852], [5.0, 11.25], [5.073512855247171, 11.253611454995852], [5.146317741512096, 11.264411039697578], [5.2177135079408465, 11.282294748200844], [5.287012574273818, 11.307090350616535], [5.353547552619498, 11.338559051738734], [5.416677674764702, 11.37639779077309], [5.475794963122734, 11.420242159977947]]], [[[20.0, 25.0], [20.0, 12.15], [10.15, 12.15], [10.15, 25.0], [20.0, 25.0]]], [[[3.3253544124686343, 22.50799818519531], [3.383210818105248, 22.669696006638908], [3.4566377873903784, 22.824944289445497], [3.5449281784705455, 22.972247907784304], [3.64723170661521, 23.11018824728638], [3.7625631329235416, 23.237436867076458], [3.8898117527136193, 23.352768293384788], [4.027752092215696, 23.455071821529454], [4.175055710554504, 23.543362212609622], [4.330303993361092, 23.616789181894752], [4.4920018148046905, 23.674645587531366], [4.658591936471775, 23.716374240705655], [4.828470004423269, 23.741573271676344], [5.0, 23.75], [5.17152999557673, 23.741573271676344], [5.341408063528225, 23.716374240705655], [5.507998185195309, 23.674645587531366], [5.669696006638907, 23.616789181894752], [5.8249442894454955, 23.543362212609622], [5.972247907784303, 23.455071821529454], [6.11018824728638, 23.35276829338479], [6.2374368670764575, 23.237436867076458], [6.352768293384789, 23.11018824728638], [6.4550718215294545, 22.972247907784304], [6.543362212609621, 22.824944289445497], [6.6167891818947515, 22.669696006638908], [6.674645587531366, 22.50799818519531], [6.716374240705653, 22.341408063528224], [6.741573271676344, 22.17152999557673], [6.75, 22.0], [6.741573271676344, 21.82847000442327], [6.716374240705653, 21.658591936471776], [6.674645587531366, 21.49200181480469], [6.6167891818947515, 21.330303993361092], [6.543362212609622, 21.175055710554503], [6.4550718215294545, 21.027752092215696], [6.3527682933847895, 20.88981175271362], [6.237436867076458, 20.762563132923542], [6.11018824728638, 20.64723170661521], [5.972247907784304, 20.544928178470546], [5.824944289445496, 20.456637787390378], [5.669696006638907, 20.383210818105248], [5.507998185195309, 20.325354412468634], [5.341408063528225, 20.283625759294345], [5.171529995576732, 20.258426728323656], [5.0, 20.25], [4.828470004423269, 20.258426728323656], [4.658591936471776, 20.283625759294345], [4.492001814804691, 20.325354412468634], [4.330303993361093, 20.383210818105248], [4.1750557105545045, 20.456637787390378], [4.027752092215697, 20.544928178470546], [3.8898117527136207, 20.64723170661521], [3.7744680589134334, 20.751773136955222], [3.762563132923542, 20.762563132923542], [3.6472317066152105, 20.88981175271362], [3.5449281784705455, 21.027752092215696], [3.456637787390379, 21.175055710554503], [3.3832108181052485, 21.330303993361092], [3.3253544124686343, 21.49200181480469], [3.2836257592943467, 21.658591936471776], [3.2584267283236557, 21.82847000442327], [3.25, 22.0], [3.2584267283236557, 22.17152999557673], [3.2836257592943467, 22.341408063528224], [3.3253544124686343, 22.50799818519531]]]]} | 0.708225 | 266.161 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Net area; waste not included | NEW | PK.50.50.C | PK.50.20.C;PK.50.50.C;PK.70.10.C | C_check;C_soil;C_turf | 3 | 잔디 | 20 수목·녹지 | LCS_ModelDetail - SodModuleX_m: 0.3; SodModuleY_m: 0.3; SodMethod: Flat sod full coverage; NetSodEquivalent: 2957.35; LCS_WBS - NurseryOrFacilitySpecification: 평떼 300×300mm / 전면 붙임
lawn_D | 잔디마당 / lawn_D | VEGETATION | PK.50.50.D 평떼 잔디붙임 / D구역 (평떼 잔디붙임) | lawn_D | lawn | D | {"type": "MultiPolygon", "coordinates": [[[[24.15, 0.0], [24.15, 4.15], [21.15, 4.15], [21.15, 9.85], [32.15, 9.85], [32.15, 11.85], [38.15, 11.85], [38.15, 22.15], [32.15, 22.15], [32.15, 25.0], [33.148054245283014, 25.0], [33.154687499999994, 24.98125], [33.3140625, 24.69375], [33.515625, 24.450000000000003], [33.759375000000006, 24.249999999999996], [34.0453125, 24.093749999999996], [34.3734375, 23.981249999999996], [34.743750000000006, 23.912499999999998], [35.15625, 23.887500000000003], [35.5625, 23.887500000000003], [35.78521293375395, 23.901419558359624], [35.8704453232657, 23.90674658270411], [35.87639779077309, 23.916677674764703], [35.838559051738734, 23.8535475526195], [35.807090350616534, 23.787012574273817], [35.78229474820084, 23.717713507940847], [35.76441103969758, 23.646317741512096], [35.753611454995855, 23.57351285524717], [35.75, 23.5], [35.753611454995855, 23.42648714475283], [35.76441103969758, 23.353682258487904], [35.78229474820084, 23.282286492059153], [35.807090350616534, 23.212987425726183], [35.838559051738734, 23.1464524473805], [35.87639779077309, 23.083322325235297], [35.920242159977946, 23.024205036877266], [35.96966991411009, 22.96966991411009], [36.02420503687726, 22.920242159977946], [36.0833223252353, 22.87639779077309], [36.146452447380504, 22.838559051738734], [36.21298742572618, 22.807090350616534], [36.28228649205915, 22.782294748200844], [36.3536822584879, 22.764411039697578], [36.42648714475283, 22.753611454995852], [36.5, 22.75], [36.57351285524717, 22.753611454995852], [36.6463177415121, 22.764411039697578], [36.71771350794085, 22.782294748200844], [36.78701257427382, 22.807090350616534], [36.853547552619496, 22.838559051738734], [36.9166776747647, 22.87639779077309], [36.97579496312274, 22.920242159977946], [37.03033008588991, 22.96966991411009], [37.079757840022054, 23.024205036877266], [37.12360220922691, 23.083322325235297], [37.161440948261266, 23.1464524473805], [37.192909649383466, 23.212987425726183], [37.21770525179916, 23.282286492059153], [37.23558896030242, 23.353682258487904], [37.246388545004145, 23.42648714475283], [37.25, 23.5], [37.246388545004145, 23.57351285524717], [37.23558896030242, 23.646317741512096], [37.21770525179916, 23.717713507940847], [37.192909649383466, 23.787012574273817], [37.161440948261266, 23.8535475526195], [37.12360220922691, 23.916677674764703], [37.079757840022054, 23.975794963122734], [37.03033008588991, 24.03033008588991], [36.97579496312274, 24.079757840022054], [36.95726167598354, 24.093503062553058], [37.125, 24.137500000000003], [37.5, 24.2625], [37.86875, 24.412499999999998], [38.231249999999996, 24.587500000000002], [38.545312499999994, 24.8], [38.7578125, 25.0], [40.0, 25.0], [40.0, 0.0], [24.15, 0.0]], [[38.021875, 0.996875], [38.440625, 1.140625], [38.787499999999994, 1.34375], [39.0625, 1.6062500000000002], [39.265625, 1.928125], [39.39687500000001, 2.309375], [39.456250000000004, 2.75], [39.446115288220554, 3.1553884711779445], [39.44375, 3.25], [39.4046875, 3.715625], [39.3390625, 4.146875], [39.246874999999996, 4.543749999999999], [39.128125, 4.90625], [38.982812499999994, 5.234375], [38.8109375, 5.528125000000001], [38.612500000000004, 5.7875000000000005], [38.387499999999996, 6.012499999999999], [38.134375, 6.203124999999999], [37.853125000000006, 6.359374999999999], [37.54375, 6.481249999999999], [37.206250000000004, 6.56875], [36.840625, 6.621874999999999], [36.446875, 6.640625], [36.025, 6.625], [35.574999999999996, 6.575], [35.14218749999999, 6.509375], [34.7265625, 6.4281250000000005], [34.328125, 6.331250000000001], [33.946875000000006, 6.21875], [33.5828125, 6.090625], [33.2359375, 5.946875], [32.90625, 5.7875], [32.59375, 5.6125], [32.25, 5.4828125], [31.875, 5.398437499999999], [31.46875, 5.359375], [31.03125, 5.3656250000000005], [30.5625, 5.417187500000001], [30.0625, 5.5140625], [29.53125, 5.65625], [28.96875, 5.84375], [28.4375, 5.9703125], [27.9375, 6.035937499999999], [27.46875, 6.0406249999999995], [27.03125, 5.984375], [26.625, 5.867187500000001], [26.25, 5.6890625], [25.90625, 5.45], [25.704047171651442, 5.255885284785383], [25.717705251799156, 5.2177135079408465], [25.692909649383466, 5.287012574273818], [25.661440948261266, 5.353547552619498], [25.62360220922691, 5.416677674764702], [25.57975784002205, 5.475794963122734], [25.53033008588991, 5.5303300858899105], [25.475794963122734, 5.579757840022053], [25.416677674764703, 5.62360220922691], [25.3535475526195, 5.661440948261267], [25.287012574273817, 5.6929096493834646], [25.217713507940847, 5.717705251799156], [25.146317741512096, 5.735588960302422], [25.07351285524717, 5.746388545004148], [25.0, 5.75], [24.92648714475283, 5.746388545004148], [24.853682258487904, 5.735588960302422], [24.782286492059153, 5.717705251799156], [24.712987425726183, 5.6929096493834646], [24.6464524473805, 5.661440948261266], [24.583322325235297, 5.623602209226909], [24.524205036877266, 5.579757840022053], [24.46966991411009, 5.5303300858899105], [24.420242159977946, 5.475794963122734], [24.37639779077309, 5.416677674764702], [24.338559051738734, 5.353547552619498], [24.307090350616534, 5.287012574273818], [24.282294748200844, 5.2177135079408465], [24.264411039697578, 5.146317741512096], [24.253611454995852, 5.07351285524717], [24.25, 5.0], [24.253611454995852, 4.926487144752829], [24.264411039697578, 4.853682258487903], [24.282294748200844, 4.7822864920591535], [24.307090350616534, 4.712987425726182], [24.338559051738734, 4.646452447380502], [24.37639779077309, 4.583322325235298], [24.420242159977946, 4.524205036877266], [24.46966991411009, 4.4696699141100895], [24.524205036877266, 4.420242159977947], [24.583322325235297, 4.376397790773091], [24.6464524473805, 4.338559051738733], [24.712987425726183, 4.3070903506165354], [24.782286492059153, 4.282294748200844], [24.853682258487904, 4.264411039697578], [24.92627550521199, 4.253642848756145], [24.890625, 4.193749999999999], [24.734375, 3.8562499999999993], [24.6171875, 3.5093749999999995], [24.5390625, 3.1531249999999997], [24.5, 2.7874999999999996], [24.5, 2.4125], [24.5859375, 2.0765625], [24.7578125, 1.7796875], [25.015625, 1.521875], [25.359375, 1.303125], [25.7890625, 1.1234375], [26.3046875, 0.9828125000000001], [26.90625, 0.8812500000000001], [27.59375, 0.81875], [28.2734375, 0.7671874999999999], [28.9453125, 0.7265625], [29.609375, 0.6968749999999999], [30.265625, 0.6781249999999999], [30.9140625, 0.6703124999999999], [31.5546875, 0.6734374999999999], [32.1875, 0.6875], [32.8125, 0.7125], [33.4296875, 0.7375], [34.0390625, 0.7625000000000001], [34.640625, 0.7875000000000001], [35.234375, 0.8125], [35.8203125, 0.8375], [36.3984375, 0.8625], [36.96875, 0.8875], [37.53125, 0.9125], [38.021875, 0.996875]], [[37.47579496312274, 8.420242159977947], [37.53033008588991, 8.469669914110089], [37.579757840022054, 8.524205036877266], [37.62360220922691, 8.583322325235299], [37.661440948261266, 8.646452447380502], [37.692909649383466, 8.712987425726183], [37.71770525179916, 8.782286492059153], [37.73558896030242, 8.853682258487904], [37.746388545004145, 8.92648714475283], [37.75, 9.0], [37.746388545004145, 9.07351285524717], [37.73558896030242, 9.146317741512096], [37.71770525179916, 9.217713507940847], [37.692909649383466, 9.287012574273819], [37.661440948261266, 9.3535475526195], [37.62360220922691, 9.416677674764701], [37.579757840022054, 9.475794963122734], [37.53033008588991, 9.530330085889911], [37.47579496312274, 9.579757840022053], [37.4166776747647, 9.62360220922691], [37.353547552619496, 9.661440948261266], [37.28701257427382, 9.692909649383465], [37.21771350794084, 9.717705251799156], [37.1463177415121, 9.735588960302422], [37.07351285524717, 9.746388545004148], [37.0, 9.75], [36.92648714475283, 9.746388545004148], [36.8536822584879, 9.735588960302422], [36.78228649205915, 9.717705251799156], [36.71298742572618, 9.692909649383465], [36.646452447380504, 9.661440948261266], [36.5833223252353, 9.62360220922691], [36.52420503687726, 9.579757840022053], [36.46966991411009, 9.530330085889911], [36.420242159977946, 9.475794963122734], [36.37639779077309, 9.416677674764701], [36.338559051738734, 9.353547552619498], [36.307090350616534, 9.287012574273817], [36.28229474820084, 9.217713507940847], [36.26441103969758, 9.146317741512096], [36.253611454995855, 9.07351285524717], [36.25, 9.0], [36.253611454995855, 8.92648714475283], [36.26441103969758, 8.853682258487904], [36.28229474820084, 8.782286492059153], [36.307090350616534, 8.712987425726183], [36.338559051738734, 8.646452447380502], [36.37639779077309, 8.583322325235299], [36.420242159977946, 8.524205036877266], [36.46966991411009, 8.469669914110089], [36.52420503687726, 8.420242159977947], [36.5833223252353, 8.37639779077309], [36.646452447380504, 8.338559051738734], [36.71298742572618, 8.307090350616535], [36.78228649205915, 8.282294748200844], [36.8536822584879, 8.264411039697578], [36.92648714475283, 8.253611454995852], [37.0, 8.25], [37.07351285524717, 8.253611454995852], [37.1463177415121, 8.264411039697578], [37.21771350794085, 8.282294748200844], [37.28701257427382, 8.307090350616535], [37.353547552619496, 8.338559051738734], [37.4166776747647, 8.37639779077309], [37.47579496312274, 8.420242159977947]]], [[[20.0, 12.15], [20.0, 25.0], [29.85, 25.0], [29.85, 12.15], [20.0, 12.15]]]]} | 0.560475 | 274.609 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 | Net area; waste not included | NEW | PK.50.50.D | PK.50.20.D;PK.50.50.D;PK.70.10.D | D_check;D_soil;D_turf | 3 | 잔디 | 20 수목·녹지 | LCS_ModelDetail - SodModuleX_m: 0.3; SodModuleY_m: 0.3; SodMethod: Flat sod full coverage; NetSodEquivalent: 3051.21; LCS_WBS - NurseryOrFacilitySpecification: 평떼 300×300mm / 전면 붙임
