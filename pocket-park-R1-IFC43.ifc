Properties of the parts of a building model (IFC4X3_ADD2), part 9 of 9

# IfcTask: EXECUTABLE_TASK (62)
Name | Description | Identification = WBSCode | LongDescription | WorkMethod | PredefinedType | Classification | TaskJSON | ParentWBSCode | LegacyTaskId | WorkZones | ScopeObjectIds | WorkQuantity | WorkQuantityUnit | Status | CalculationJSON | PlannedNetWorkHours | Planned8HourCrewDays | SetupHours | TravelAllowanceHours | ResourceBundleJSON | EquipmentRequirement | IncludedWork | PrimaryCode | Title | Clauses | RelatedCodes | ApplicationNote | SourceURL
쇄석 포장기층 / D구역 | P2 작업 D_subbase / 작업량 132.0 m2 | PK.40.10.D | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / subbase | CONSTRUCTION | PK.40.10.D 쇄석 포장기층 / D구역 (쇄석 포장기층); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "D_subbase", "wbs_code": "PK.40.10.D", "zone_id": "D", "activity_type": "subbase", "input_object_ids": ["plaza_D", "walkway_D"], "output_object_ids": [], "quantity": 132.0, "unit": "m2", "predecessors": ["D_curb", "D_trees", "D_pergola"], "lag": 0, "required_resource_bundle": {"crew_paver": 2, "crew_special": 2, "crew_general": 1}, "productivity": 18, "productivity_unit": "m2/crew_hour", "productivity_model_id": "subbase_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "40", "parent_wbs_code": "PK.40.10", "wbs_name": "쇄석 포장기층 / D구역", "task_guid": "3v5$yVh5XHqRQZyLa758Ke", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_curb": 0, "D_trees": 0, "D_pergola": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정.", "planned_net_work_hours": 7.333333333333333, "planned_8h_crew_days": 0.9166666666666666, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.40.10 | D_subbase | D | ["ZONE_D"] | 132 | m2 | ASSUMED_NOT_VERIFIED | [] | 7.33333 | 0.916667 | 0.2 | 0.1 | {"crew_paver": 2, "crew_special": 2, "crew_general": 1} | 기존 합성모델 장비 가정 | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. | KCS 34 60 05 | 조경포장공통 | 3.3.3 원지반 정지 및 다짐; 3.3.4 쇄석기층 | KCS 34 60 15 | 블록포장 하부의 쇄석기층. 두께·다짐도·계획고를 검측한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
포장 기층 검사 / D구역 | P2 작업 D_pavecheck / 작업량 1 ea | PK.40.20.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / pavecheck | INSPECTION | PK.40.20.D 포장 기층 검사 / D구역 (포장 기층 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "D_pavecheck", "wbs_code": "PK.40.20.D", "zone_id": "D", "activity_type": "pavecheck", "input_object_ids": ["plaza_D", "walkway_D"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["D_subbase"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 2, "productivity_unit": "ea/crew_hour", "productivity_model_id": "pavecheck_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "41", "parent_wbs_code": "PK.40.20", "wbs_name": "포장 기층 검사 / D구역", "task_guid": "1mFe$AFOnLlP1bScivpQVV", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_subbase": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.5, "planned_8h_crew_days": 0.0625, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.40.20 | D_pavecheck | D | ["ZONE_D"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 0.5 | 0.0625 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 05 | 조경포장공통 | 3.4 시공허용오차; 3.6 현장품질관리 | KCS 34 60 15; KCS 34 10 10 | 포장 기층 검사. 시험·검측을 통과했다는 의미가 아닌 기준 연결이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
모래·콘크리트블록 포장 / D구역 | P2 작업 D_finish / 작업량 132.0 m2 | PK.40.30.D | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / finish | CONSTRUCTION | PK.40.30.D 모래·콘크리트블록 포장 / D구역 (모래·콘크리트블록 포장); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "D_finish", "wbs_code": "PK.40.30.D", "zone_id": "D", "activity_type": "finish", "input_object_ids": [], "output_object_ids": ["plaza_D", "walkway_D"], "quantity": 132.0, "unit": "m2", "predecessors": ["D_pavecheck"], "lag": 0, "required_resource_bundle": {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1}, "productivity": 37.5, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": "D", "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "42", "parent_wbs_code": "PK.40.30", "wbs_name": "모래·콘크리트블록 포장 / D구역", "task_guid": "3yndDAaojVGfVpR1$YFOQp", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"D_pavecheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374"], "norm_breakdown": [{"rate_key": "PAVING_A", "quantity": 132.0, "daily_output": 300, "hours": 3.52, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 3.52, "equipment_requirement": "굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "깔기모래·블록 절단 및 설치·줄눈채움·후다짐", "planned_net_work_hours": 3.52, "planned_8h_crew_days": 0.44, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.40.30 | D_finish | D | ["ZONE_D"] | 132 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "PAVING_A", "quantity": 132.0, "daily_output": 300, "hours": 3.52, "status": "CONDITIONAL_SITE"}] | 3.52 | 0.44 | 0 | 0.1 | {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1} | 굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대 | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 | KCS 34 60 15 | 친환경블록포장 | 2.1.1 소형고압블록; 3.2.2 소형고압블록포장 | KCS 34 60 05; KCS 34 60 25 | 200×200mm 콘크리트블록을 소형고압블록 계열로 잠정 매칭. 제품 KS·물성은 자재 승인 시 확정한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2015%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374; NetCrewHours: 3.52
관목 식재 / D구역 | P2 작업 D_shrubs / 작업량 137 ea | PK.50.40.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / shrubs | INSTALLATION | PK.50.40.D 관목 식재 / D구역 (관목 식재); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "D_shrubs", "wbs_code": "PK.50.40.D", "zone_id": "D", "activity_type": "shrubs", "input_object_ids": [], "output_object_ids": ["P2_B02-001", "P2_B02-002", "P2_B02-003", "P2_B02-004", "P2_B02-005", "P2_B02-006", "P2_B02-007", "P2_B02-008", "P2_B02-009", "P2_B02-010", "P2_B02-011", "P2_B02-012", "P2_B02-013", "P2_B02-014", "P2_B02-015", "P2_B02-016", "P2_B02-017", "P2_B02-018", "P2_B02-019", "P2_B02-020", "P2_B02-021", "P2_B02-022", "P2_B02-023", "P2_B02-024", "P2_B02-025", "P2_B02-026", "P2_B02-027", "P2_B02-028", "P2_B02-029", "P2_B02-030", "P2_B02-031", "P2_B02-032", "P2_B02-033", "P2_B02-034", "P2_B02-035", "P2_B02-036", "P2_B02-037", "P2_B02-038", "P2_B02-039", "P2_B02-040", "P2_B02-041", "P2_B02-042", "P2_B02-043", "P2_B02-044", "P2_B02-045", "P2_B02-046", "P2_B02-047", "P2_B02-048", "P2_B02-049", "P2_B02-050", "P2_B02-051", "P2_B02-052", "P2_B02-053", "P2_B02-054", "P2_B02-055", "P2_B02-056", "P2_B02-057", "P2_B02-058", "P2_B02-059", "P2_B02-060", "P2_B02-061", "P2_B02-062", "P2_B02-063", "P2_B02-064", "P2_B02-065", "P2_B02-066", "P2_B02-067", "P2_B02-068", "P2_B02-069", "P2_B02-070", "P2_B02-071", "P2_B02-072", "P2_B02-073", "P2_B02-074", "P2_B02-075", "P2_B02-076", "P2_B02-077", "P2_B02-078", "P2_B02-079", "P2_B02-080", "P2_B02-081", "P2_B02-082", "P2_B02-083", "P2_B02-084", "P2_B02-085", "P2_B02-086", "P2_B02-087", "P2_B02-088", "P2_B02-089", "P2_B02-090", "P2_B02-091", "P2_B02-092", "P2_B02-093", "P2_B02-094", "P2_B02-095", "P2_B02-096", "P2_B02-097", "P2_B02-098", "P2_B02-099", "P2_B02-100", "P2_S01-001", "P2_S01-002", "P2_Y02-001", "P2_Y02-002", "P2_Y02-003", "P2_Y02-004", "P2_Y02-005", "P2_Y02-006", "P2_Y02-007", "P2_Y02-008", "P2_Y02-009", "P2_Y02-010", "P2_Y02-011", "P2_Y02-012", "P2_Y02-013", "P2_Y02-014", "P2_Y02-015", "P2_Y02-016", "P2_Y02-017", "P2_Y02-018", "P2_Y02-019", "P2_Y02-020", "P2_Y02-021", "P2_Y02-022", "P2_Y02-023", "P2_Y02-024", "P2_Y02-025", "P2_Y02-026", "P2_Y02-027", "P2_Y02-028", "P2_Y02-029", "P2_Y02-030", "P2_Y02-031", "P2_Y02-032", "P2_Y05-001", "P2_Y05-002", "P2_Y05-003"], "quantity": 137, "unit": "ea", "predecessors": ["D_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1}, "productivity": 13.240979381443298, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "53", "parent_wbs_code": "PK.50.40", "wbs_name": "관목 식재 / D구역", "task_guid": "2lNFjVF3XTvO7rdvjQNo6m", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"D_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149"], "norm_breakdown": [{"rate_key": "SHRUB_B", "quantity": 100, "daily_output": 125, "hours": 6.4, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 2, "daily_output": 75, "hours": 0.21333333333333335, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 35, "daily_output": 75, "hours": 3.7333333333333334, "status": "SPEC_MATCHED"}], "norm_work_hours": 10.346666666666668, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 10.346666666666668, "planned_8h_crew_days": 1.2933333333333334, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.40 | D_shrubs | D | ["ZONE_D"] | 137 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "SHRUB_B", "quantity": 100, "daily_output": 125, "hours": 6.4, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 2, "daily_output": 75, "hours": 0.21333333333333335, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 35, "daily_output": 75, "hours": 3.7333333333333334, "status": "SPEC_MATCHED"}] | 10.3467 | 1.29333 | 0 | 0.03 | {"crew_landscaper": 3, "crew_general": 1} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 관목의 배식 간격·식재·관수. 품셈의 단식/군식 판정과 시방 적용은 서로 다른 정보이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149; NetCrewHours: 10.3467
평떼 잔디붙임 / D구역 | P2 작업 D_turf / 작업량 274.608895 m2 | PK.50.50.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / turf | INSTALLATION | PK.50.50.D 평떼 잔디붙임 / D구역 (평떼 잔디붙임); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 25 잔디식재 (KCS 조경공사 표준시방서) | {"task_id": "D_turf", "wbs_code": "PK.50.50.D", "zone_id": "D", "activity_type": "turf", "input_object_ids": [], "output_object_ids": ["lawn_D"], "quantity": 274.6088946778756, "unit": "m2", "predecessors": ["D_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 4}, "productivity": 18.75, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "54", "parent_wbs_code": "PK.50.50", "wbs_name": "평떼 잔디붙임 / D구역", "task_guid": "1xqy6j7lDSUQrwc6EQSc0d", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"D_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-1-1 잔디붙임 / 인쇄91 / PDF147"], "norm_breakdown": [{"rate_key": "TURF", "quantity": 274.6088946778756, "daily_output": 150, "hours": 14.645807716153364, "status": "CONDITIONAL_METHOD"}], "norm_work_hours": 14.645807716153364, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 14.645807716153364, "planned_8h_crew_days": 1.8307259645191705, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.50 | D_turf | D | ["ZONE_D"] | 274.609 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "TURF", "quantity": 274.6088946778756, "daily_output": 150, "hours": 14.645807716153364, "status": "CONDITIONAL_METHOD"}] | 14.6458 | 1.83073 | 0 | 0.03 | {"crew_landscaper": 1, "crew_general": 4} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 25 | 잔디식재 | 2.1.1 잔디; 3.1.1 잔디식재 시공일반 | KCS 34 40 05; KCS 34 30 10 | 300×300mm 평떼 전면붙임. 반입 후 1일 이내 식재 조건을 고려한 반입 분할 계획은 아직 모델화하지 않았다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2025%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-1-1 잔디붙임 / 인쇄91 / PDF147; NetCrewHours: 14.6458
수목 하부 멀칭 / D구역 | P2 작업 D_mulch / 작업량 7.057234 m2 | PK.50.60.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / mulch | CONSTRUCTION | PK.50.60.D 수목 하부 멀칭 / D구역 (수목 하부 멀칭); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "D_mulch", "wbs_code": "PK.50.60.D", "zone_id": "D", "activity_type": "mulch", "input_object_ids": [], "output_object_ids": ["green_D"], "quantity": 7.057234103728366, "unit": "m2", "predecessors": ["D_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 25, "productivity_unit": "m2/crew_hour", "productivity_model_id": "mulch_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "55", "parent_wbs_code": "PK.50.60", "wbs_name": "수목 하부 멀칭 / D구역", "task_guid": "3jIwiso2zK08gyhvYvk2yk", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.28228936414913464, "planned_8h_crew_days": 0.03528617051864183, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.50.60 | D_mulch | D | ["ZONE_D"] | 7.05723 | m2 | ASSUMED_NOT_VERIFIED | [] | 0.282289 | 0.0352862 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 2.2.1 멀칭재 | KCS 34 40 05 | 수목 하부 멀칭재 품질 기준. 두께·시공 범위는 설계 가정이며 해당 조항이 수치를 확정하지 않는다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10
벤치 설치 / D구역 | P2 작업 D_bench / 작업량 2 ea | PK.60.10.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / bench | INSTALLATION | PK.60.10.D 벤치 설치 / D구역 (벤치 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 15 현장제작설치 시설 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "D_bench", "wbs_code": "PK.60.10.D", "zone_id": "D", "activity_type": "bench", "input_object_ids": [], "output_object_ids": ["BENCH01", "BENCH02"], "quantity": 2, "unit": "ea", "predecessors": ["D_foundation", "D_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 0.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "bench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 24, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "60", "parent_wbs_code": "PK.60.10", "wbs_name": "벤치 설치 / D구역", "task_guid": "1cV9jjJRHIjuIqr2q2nErS", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_foundation": 24.0, "D_finish": 0.0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 4.0, "planned_8h_crew_days": 0.5, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.60.10 | D_bench | D | ["ZONE_D"] | 2 | ea | ASSUMED_NOT_VERIFIED | [] | 4 | 0.5 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 20 | 옥외시설물 | 2.1.11 옥외용 벤치; 3.2.2 의자 | KCS 34 50 05; KCS 34 50 15 | 벤치 높이·기초·앵커·체결·마감 확인. 재료별 관련 시방을 함께 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2020%3A2024-12-10
퍼걸러 설치 / D구역 | P2 작업 D_pergola / 작업량 1 ea | PK.60.20.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / pergola | INSTALLATION | PK.60.20.D 퍼걸러 설치 / D구역 (퍼걸러 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 15 현장제작설치 시설 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "D_pergola", "wbs_code": "PK.60.20.D", "zone_id": "D", "activity_type": "pergola", "input_object_ids": [], "output_object_ids": ["PERGOLA01"], "quantity": 1, "unit": "ea", "predecessors": ["D_foundation"], "lag": 0, "required_resource_bundle": {"excavator": 1, "crew_landscaper": 1, "crew_general": 2}, "productivity": 0.0625, "productivity_unit": "ea/crew_hour", "productivity_model_id": "pergola_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 24, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "60", "parent_wbs_code": "PK.60.20", "wbs_name": "퍼걸러 설치 / D구역", "task_guid": "3Rvg5nVnXUWut1Q3eG$WzC", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_foundation": 24.0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 16.0, "planned_8h_crew_days": 2.0, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.60.20 | D_pergola | D | ["ZONE_D"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 16 | 2 | 0.2 | 0.1 | {"excavator": 1, "crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 20 | 옥외시설물 | 3.2.4 퍼걸러 | KCS 34 50 05; KCS 34 50 15 | 4.0×4.0m 퍼걸러의 수직·접합·배수·재료별 방부 등. 구조안전·제품 상세는 별도 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2020%3A2024-12-10
구역 마무리 검사 / D구역 | P2 작업 D_check / 작업량 1 ea | PK.70.10.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / check | INSPECTION | PK.70.10.D 구역 마무리 검사 / D구역 (구역 마무리 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "D_check", "wbs_code": "PK.70.10.D", "zone_id": "D", "activity_type": "check", "input_object_ids": ["BENCH01", "BENCH02", "CHAMBER_D", "CURB_D", "P2_B02-001", "P2_B02-002", "P2_B02-003", "P2_B02-004", "P2_B02-005", "P2_B02-006", "P2_B02-007", "P2_B02-008", "P2_B02-009", "P2_B02-010", "P2_B02-011", "P2_B02-012", "P2_B02-013", "P2_B02-014", "P2_B02-015", "P2_B02-016", "P2_B02-017", "P2_B02-018", "P2_B02-019", "P2_B02-020", "P2_B02-021", "P2_B02-022", "P2_B02-023", "P2_B02-024", "P2_B02-025", "P2_B02-026", "P2_B02-027", "P2_B02-028", "P2_B02-029", "P2_B02-030", "P2_B02-031", "P2_B02-032", "P2_B02-033", "P2_B02-034", "P2_B02-035", "P2_B02-036", "P2_B02-037", "P2_B02-038", "P2_B02-039", "P2_B02-040", "P2_B02-041", "P2_B02-042", "P2_B02-043", "P2_B02-044", "P2_B02-045", "P2_B02-046", "P2_B02-047", "P2_B02-048", "P2_B02-049", "P2_B02-050", "P2_B02-051", "P2_B02-052", "P2_B02-053", "P2_B02-054", "P2_B02-055", "P2_B02-056", "P2_B02-057", "P2_B02-058", "P2_B02-059", "P2_B02-060", "P2_B02-061", "P2_B02-062", "P2_B02-063", "P2_B02-064", "P2_B02-065", "P2_B02-066", "P2_B02-067", "P2_B02-068", "P2_B02-069", "P2_B02-070", "P2_B02-071", "P2_B02-072", "P2_B02-073", "P2_B02-074", "P2_B02-075", "P2_B02-076", "P2_B02-077", "P2_B02-078", "P2_B02-079", "P2_B02-080", "P2_B02-081", "P2_B02-082", "P2_B02-083", "P2_B02-084", "P2_B02-085", "P2_B02-086", "P2_B02-087", "P2_B02-088", "P2_B02-089", "P2_B02-090", "P2_B02-091", "P2_B02-092", "P2_B02-093", "P2_B02-094", "P2_B02-095", "P2_B02-096", "P2_B02-097", "P2_B02-098", "P2_B02-099", "P2_B02-100", "P2_D03", "P2_I02", "P2_I03", "P2_I06", "P2_S01-001", "P2_S01-002", "P2_Y02-001", "P2_Y02-002", "P2_Y02-003", "P2_Y02-004", "P2_Y02-005", "P2_Y02-006", "P2_Y02-007", "P2_Y02-008", "P2_Y02-009", "P2_Y02-010", "P2_Y02-011", "P2_Y02-012", "P2_Y02-013", "P2_Y02-014", "P2_Y02-015", "P2_Y02-016", "P2_Y02-017", "P2_Y02-018", "P2_Y02-019", "P2_Y02-020", "P2_Y02-021", "P2_Y02-022", "P2_Y02-023", "P2_Y02-024", "P2_Y02-025", "P2_Y02-026", "P2_Y02-027", "P2_Y02-028", "P2_Y02-029", "P2_Y02-030", "P2_Y02-031", "P2_Y02-032", "P2_Y05-001", "P2_Y05-002", "P2_Y05-003", "PERGOLA01", "PIPE_D", "green_D", "lawn_D", "plaza_D", "shrub_D", "walkway_D"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["D_shrubs", "D_turf", "D_mulch", "D_bench", "D_pergola"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 1, "productivity_unit": "ea/crew_hour", "productivity_model_id": "check_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "70", "parent_wbs_code": "PK.70.10", "wbs_name": "구역 마무리 검사 / D구역", "task_guid": "164omsjYPJa9_Pi5RLjGJg", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_shrubs": 0, "D_turf": 0, "D_mulch": 0, "D_bench": 0, "D_pergola": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.0, "planned_8h_crew_days": 0.125, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.10 | D_check | D | ["ZONE_D"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 1 | 0.125 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.6.2 품질시험·검사; 3.1.1 시공 확인 및 검사 | KCS 34 40 05; KCS 34 60 05; KCS 34 50 05 | 구역 종합검사 공통 기준. 해당 구역의 식재·포장·시설물 세부 기준을 함께 대조한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
임시동선 복구 / 전체 | P2 작업 RESTORE / 작업량 1 ea | PK.70.20.SITE | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / RESTORE | RENOVATION | PK.70.20.SITE 임시동선 복구 / 전체 (임시동선 복구); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "RESTORE", "wbs_code": "PK.70.20.SITE", "zone_id": "SITE", "activity_type": "RESTORE", "input_object_ids": ["ACCESS_A", "ACCESS_B", "ACCESS_C", "ACCESS_D", "ACCESS_trunk"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["A_check", "B_check", "C_check", "D_check"], "lag": 0, "required_resource_bundle": {"earth_crew": 1}, "productivity": 0.25, "productivity_unit": "ea/crew_hour", "productivity_model_id": "RESTORE_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_SITE", "work_zones": ["SITE"], "access_node_id": "SITE", "heavy": false, "closes": "trunk", "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "71", "parent_wbs_code": "PK.70.20", "wbs_name": "임시동선 복구 / 전체", "task_guid": "0dt$1QUmrUhvcqPNX1gO8o", "ifc_predefined_type": "RENOVATION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_check": 0, "B_check": 0, "C_check": 0, "D_check": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 4.0, "planned_8h_crew_days": 0.5, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.20 | RESTORE | SITE | ["TERRAIN"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 4 | 0.5 | 0.2 | 0.03 | {"earth_crew": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.7.4 자연환경 보전; 3.1.1 시공 확인 및 검사 | KCS 34 20 10; KCS 34 60 05 | 임시동선 복구의 공통 기준. 실제 훼손 피복·식재 복구 범위에 따라 세부 기준을 확정한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
준공검사 / 전체 | P2 작업 HANDOVER / 작업량 1 ea | PK.70.30.SITE | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / HANDOVER | INSPECTION | PK.70.30.SITE 준공검사 / 전체 (준공검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "HANDOVER", "wbs_code": "PK.70.30.SITE", "zone_id": "SITE", "activity_type": "HANDOVER", "input_object_ids": ["TERRAIN"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["RESTORE"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 0.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "HANDOVER_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_SITE", "work_zones": ["SITE"], "access_node_id": "SITE", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "72", "parent_wbs_code": "PK.70.30", "wbs_name": "준공검사 / 전체", "task_guid": "3be2cWMYLN3BQh0uKZC07h", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"RESTORE": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 2.0, "planned_8h_crew_days": 0.25, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.30 | HANDOVER | SITE | ["TERRAIN"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 2 | 0.25 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.5 공사기록서류; 3.1.2 기성 및 준공 검사 | KCS 34 40 05; KCS 34 50 05; KCS 34 60 05; KCS 34 50 65 | 준공 검사·기록서류. 현재 작업은 계획이며 실적 또는 준공 인증이 아니다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
표토 제거 / 전체 | P2 작업 SITE_strip / 작업량 300.0 m3 | PK.10.10.SITE | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / strip | CONSTRUCTION | PK.10.10.SITE 표토 제거 / 전체 (표토 제거); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서) | {"task_id": "SITE_strip", "wbs_code": "PK.10.10.SITE", "zone_id": "SITE", "activity_type": "strip", "input_object_ids": ["TERRAIN"], "output_object_ids": [], "quantity": 300.0, "unit": "m3", "predecessors": [], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 12, "productivity_unit": "m3/crew_hour", "productivity_model_id": "strip_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "TERRAIN", "work_zones": ["A", "B", "C", "D"], "access_node_id": "SITE", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "10", "parent_wbs_code": "PK.10.10", "wbs_name": "표토 제거 / 전체", "task_guid": "0wh5VStxDOpRBQl4$02gXs", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 25.0, "planned_8h_crew_days": 3.125, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.10.10 | SITE_strip | A,B,C,D | ["TERRAIN"] | 300 | m3 | ASSUMED_NOT_VERIFIED | [] | 25 | 3.125 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.4.1 표토 채취; 3.4.2 표토 보관 | KCS 34 10 10 | 표토 제거·분리 적치의 시공 및 품질 항목. 재사용 여부는 설계조건에 따른다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
일반토공·정지 / 전체 | P2 작업 SITE_grade / 작업량 193.693239 m3 | PK.10.20.SITE | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / grade | CONSTRUCTION | PK.10.20.SITE 일반토공·정지 / 전체 (일반토공·정지); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서) | {"task_id": "SITE_grade", "wbs_code": "PK.10.20.SITE", "zone_id": "SITE", "activity_type": "grade", "input_object_ids": ["TERRAIN"], "output_object_ids": [], "quantity": 193.693239225132, "unit": "m3", "predecessors": ["SITE_strip"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 10, "productivity_unit": "m3/crew_hour", "productivity_model_id": "grade_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "TERRAIN", "work_zones": ["A", "B", "C", "D"], "access_node_id": "SITE", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "11", "parent_wbs_code": "PK.10.20", "wbs_name": "일반토공·정지 / 전체", "task_guid": "2Qw50kcy1Qd8IPt09I0Com", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_strip": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 19.3693239225132, "planned_8h_crew_days": 2.42116549031415, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.10.20 | SITE_grade | A,B,C,D | ["TERRAIN"] | 193.693 | m3 | ASSUMED_NOT_VERIFIED | [] | 19.3693 | 2.42117 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.3 지형변경 및 대지조형; 3.5 시공허용오차; 3.6.3 다짐도 검사 | KCS 34 10 10; KCS 34 30 10 | 전면 정지와 계획고·다짐 관리. 측량값·다짐 시험 성적은 현재 없다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
배수 기준고·관저고 측량 / 전체 | P2 작업 SITE_survey / 작업량 1 ea | PK.20.05.SITE | 전 부지정지 후 가상 TBM·방류구·집수정 관저고 및 관로 구배 확인. 4시간 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / survey | INSPECTION | PK.20.05.SITE 배수 기준고·관저고 측량 / 전체 (배수 기준고·관저고 측량); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "SITE_survey", "wbs_code": "PK.20.05.SITE", "zone_id": "SITE", "activity_type": "survey", "input_object_ids": ["CHAMBER_A", "CHAMBER_B", "CHAMBER_C", "CHAMBER_D", "PIPE_A", "PIPE_B", "PIPE_C", "PIPE_D"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["SITE_grade"], "lag": 0, "required_resource_bundle": {"inspector": 1, "earth_crew": 1}, "productivity": 0.25, "productivity_unit": "ea/crew_hour", "productivity_model_id": "inspect_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "TERRAIN", "work_zones": ["A", "B", "C", "D"], "access_node_id": "SITE", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "19", "parent_wbs_code": "PK.20.05", "wbs_name": "배수 기준고·관저고 측량 / 전체", "task_guid": "3VwCg$IGbHHgVNMMSF_X$y", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_grade": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "included_work": "전 부지정지 후 가상 TBM·방류구·집수정 관저고 및 관로 구배 확인. 4시간 가정.", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "planned_net_work_hours": 4.0, "planned_8h_crew_days": 0.5, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.05 | SITE_survey | A,B,C,D | ["TERRAIN"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 4 | 0.5 | 0.2 | 0.1 | {"inspector": 1, "earth_crew": 1} | 기존 합성모델 장비 가정 | 전 부지정지 후 가상 TBM·방류구·집수정 관저고 및 관로 구배 확인. 4시간 가정. | KCS 34 50 65 | 조경 급․배수 및 관수 | 3.1.10 배수관 설치; 3.3.1 배수공사 | KCS 34 20 10; KCS 34 10 10 | 관저고·구배 기준 설정에 관련되는 시공 항목. 독립 측량작업 자체의 전용 시방코드는 아니다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2065%3A2024-12-10
집수정·우수관 연계 시공 / 전체 | P2 작업 SITE_drainage / 작업량 83 m | PK.20.30.SITE | 집수정 4개와 DN200 우수관 83m를 공통 기준고로 연계 시공. 레벨 담당 연속 배치. 작업조 20.6시간은 기존 관로 16.6시간+집수정 4시간 가정의 합계이며 품셈 확정값 아님. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / drainage | INSTALLATION | PK.20.30.SITE 집수정·우수관 연계 시공 / 전체 (집수정·우수관 연계 시공); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "SITE_drainage", "wbs_code": "PK.20.30.SITE", "zone_id": "SITE", "activity_type": "drainage", "input_object_ids": ["CHAMBER_A", "CHAMBER_B", "CHAMBER_C", "CHAMBER_D", "PIPE_A", "PIPE_B", "PIPE_C", "PIPE_D"], "output_object_ids": ["CHAMBER_A", "CHAMBER_B", "CHAMBER_C", "CHAMBER_D", "PIPE_A", "PIPE_B", "PIPE_C", "PIPE_D"], "quantity": 83, "unit": "m", "predecessors": ["A_trench", "B_trench", "C_trench", "D_trench"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "inspector": 1}, "productivity": 4.0291262135922326, "productivity_unit": "m/crew_hour", "productivity_model_id": "pipe_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "TERRAIN", "work_zones": ["A", "B", "C", "D"], "access_node_id": "SITE", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 8, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "22", "parent_wbs_code": "PK.20.30", "wbs_name": "집수정·우수관 연계 시공 / 전체", "task_guid": "1QNME35wzTeRhIdKsqH3PQ", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_trench": 0, "B_trench": 0, "C_trench": 0, "D_trench": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "included_work": "집수정 4개와 DN200 우수관 83m를 공통 기준고로 연계 시공. 레벨 담당 연속 배치. 작업조 20.6시간은 기존 관로 16.6시간+집수정 4시간 가정의 합계이며 품셈 확정값 아님.", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "planned_net_work_hours": 20.6, "planned_8h_crew_days": 2.575, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.30 | SITE_drainage | A,B,C,D | ["TERRAIN"] | 83 | m | ASSUMED_NOT_VERIFIED | [] | 20.6 | 2.575 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "inspector": 1} | 기존 합성모델 장비 가정 | 집수정 4개와 DN200 우수관 83m를 공통 기준고로 연계 시공. 레벨 담당 연속 배치. 작업조 20.6시간은 기존 관로 16.6시간+집수정 4시간 가정의 합계이며 품셈 확정값 아님. | KCS 34 50 65 | 조경 급․배수 및 관수 | 3.1.9 배수구조물; 3.1.10 배수관 설치; 3.3.1 배수공사 | KCS 34 50 05; KCS 34 20 10 | 집수정 접속부·관 기초·하류부터 부설·관저고와 구배 확인. DN200과 매설깊이는 별도 설계 검증 대상이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2065%3A2024-12-10
관망 전체 관저고·구배 검사 / 전체 | P2 작업 SITE_draincheck / 작업량 1 ea | PK.20.40.SITE | 전체 관망 관저고·구배·접속부 확인 후 되메우기 승인. 2시간 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / draincheck | INSPECTION | PK.20.40.SITE 관망 전체 관저고·구배 검사 / 전체 (관망 전체 관저고·구배 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "SITE_draincheck", "wbs_code": "PK.20.40.SITE", "zone_id": "SITE", "activity_type": "draincheck", "input_object_ids": ["CHAMBER_A", "CHAMBER_B", "CHAMBER_C", "CHAMBER_D", "PIPE_A", "PIPE_B", "PIPE_C", "PIPE_D"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["SITE_drainage"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 0.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "inspect_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "TERRAIN", "work_zones": ["A", "B", "C", "D"], "access_node_id": "SITE", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "23", "parent_wbs_code": "PK.20.40", "wbs_name": "관망 전체 관저고·구배 검사 / 전체", "task_guid": "3NBhirqOPNgO5G87SYJ2x7", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["TERRAIN"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_drainage": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "included_work": "전체 관망 관저고·구배·접속부 확인 후 되메우기 승인. 2시간 가정.", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "planned_net_work_hours": 2.0, "planned_8h_crew_days": 0.25, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.40 | SITE_draincheck | A,B,C,D | ["TERRAIN"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 2 | 0.25 | 0.2 | 0.1 | {"inspector": 1} | 기존 합성모델 장비 가정 | 전체 관망 관저고·구배·접속부 확인 후 되메우기 승인. 2시간 가정. | KCS 34 50 65 | 조경 급․배수 및 관수 | 3.3.1 배수공사; 1.8.1 관매설공사 | KCS 34 10 10 | 되메우기 전 관저고·접속부 검사에 연결. 1.8.1의 되메우기 후 수량검측·승인은 별도로 확인해야 한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2065%3A2024-12-10

# IfcTask: WBS_SUMMARY (30)
Status: PLANNED; IsMilestone: no
LCS_WBS - NodeRole: SUMMARY; ClassificationBasis: PROJECT_DEFINED_NOT_IFC_MANDATED_CODES; ClassificationVersion: R1-WBS2
Name | Identification = WBSCode | Classification | HierarchyLevel | ParentWBSCode
소공원 조성공사 | PK | PK 소공원 조성공사 (Pocket Park Construction WBS) | 0
표토·일반토공 | PK.10 | PK.10 표토·일반토공 (소공원 조성공사) | 1 | PK
표토 제거 | PK.10.10 | PK.10.10 표토 제거 (표토·일반토공) | 2 | PK.10
일반토공·정지 | PK.10.20 | PK.10.20 일반토공·정지 (표토·일반토공) | 2 | PK.10
우배수공 | PK.20 | PK.20 우배수공 (소공원 조성공사) | 1 | PK
배수 기준고·관저고 측량 | PK.20.05 | PK.20.05 배수 기준고·관저고 측량 (우배수공) | 2 | PK.20
관로·집수정 굴착 | PK.20.10 | PK.20.10 관로·집수정 굴착 (우배수공) | 2 | PK.20
집수정·우수관 연계 시공 | PK.20.30 | PK.20.30 집수정·우수관 연계 시공 (우배수공) | 2 | PK.20
관망 전체 관저고·구배 검사 | PK.20.40 | PK.20.40 관망 전체 관저고·구배 검사 (우배수공) | 2 | PK.20
되메우기·다짐 | PK.20.50 | PK.20.50 되메우기·다짐 (우배수공) | 2 | PK.20
시설기초·경계석 | PK.30 | PK.30 시설기초·경계석 (소공원 조성공사) | 1 | PK
휴게시설 기초 | PK.30.10 | PK.30.10 휴게시설 기초 (시설기초·경계석) | 2 | PK.30
화강석 경계석 설치 | PK.30.20 | PK.30.20 화강석 경계석 설치 (시설기초·경계석) | 2 | PK.30
포장공 | PK.40 | PK.40 포장공 (소공원 조성공사) | 1 | PK
쇄석 포장기층 | PK.40.10 | PK.40.10 쇄석 포장기층 (포장공) | 2 | PK.40
포장 기층 검사 | PK.40.20 | PK.40.20 포장 기층 검사 (포장공) | 2 | PK.40
모래·콘크리트블록 포장 | PK.40.30 | PK.40.30 모래·콘크리트블록 포장 (포장공) | 2 | PK.40
식재공 | PK.50 | PK.50 식재공 (소공원 조성공사) | 1 | PK
식재기반 정비 | PK.50.20 | PK.50.20 식재기반 정비 (식재공) | 2 | PK.50
교목 식재(구덩이 포함) | PK.50.30 | PK.50.30 교목 식재(구덩이 포함) (식재공) | 2 | PK.50
관목 식재 | PK.50.40 | PK.50.40 관목 식재 (식재공) | 2 | PK.50
평떼 잔디붙임 | PK.50.50 | PK.50.50 평떼 잔디붙임 (식재공) | 2 | PK.50
수목 하부 멀칭 | PK.50.60 | PK.50.60 수목 하부 멀칭 (식재공) | 2 | PK.50
휴게시설공 | PK.60 | PK.60 휴게시설공 (소공원 조성공사) | 1 | PK
벤치 설치 | PK.60.10 | PK.60.10 벤치 설치 (휴게시설공) | 2 | PK.60
퍼걸러 설치 | PK.60.20 | PK.60.20 퍼걸러 설치 (휴게시설공) | 2 | PK.60
복구·준공검사 | PK.70 | PK.70 복구·준공검사 (소공원 조성공사) | 1 | PK
구역 마무리 검사 | PK.70.10 | PK.70.10 구역 마무리 검사 (복구·준공검사) | 2 | PK.70
임시동선 복구 | PK.70.20 | PK.70.20 임시동선 복구 (복구·준공검사) | 2 | PK.70
준공검사 | PK.70.30 | PK.70.30 준공검사 (복구·준공검사) | 2 | PK.70

# IfcWorkPlan, 소공원 조성공사 계획
CreationDate: 2026-09-25T10:15:13.107790; Duration: PT4412401.255888S; StartTime: 2026-09-28T08:00:00; FinishTime: 2026-11-18T09:40:01.255888; PredefinedType: PLANNED

# IfcWorkSchedule, 소공원 R1 · WBS 기준 공정
Identification: R1-WBS2; CreationDate: 2026-09-25T10:04:39.620851; Duration: PT4412401.255888S; StartTime: 2026-09-28T08:00:00; FinishTime: 2026-11-18T09:40:01.255888; PredefinedType: PLANNED
LCS_WBS - ClassificationVersion: R1-WBS2; SourceRunId: PUMSEM2026_B1_ZONE_deterministic; ScheduleBasis: Partial 2026 standard work norms and assumed residual scopes; conditional predicted schedule; LeafTasks: 62; SummaryTasks: 30
LCS_WorkNorm - Version: 2026 user-provided first-errata PDF; NormLinkedLeafTasks: 20; ScheduleStatus: PARTIAL_NORM_CONDITIONAL_SCOPE_GAPS; CostStatus: NOT_ESTIMATED; EquipmentAccessVerified: no; UnquantifiedScopes: Kerb foundation concrete/formwork/excavation; drainage material/joint specification; equipment mobilisation and actual calendar
