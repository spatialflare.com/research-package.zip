Properties of the parts of a building model (IFC4X3_ADD2), part 8 of 9

# IfcTask: EXECUTABLE_TASK (62)
Name | Description | Identification = WBSCode | LongDescription | WorkMethod | PredefinedType | Classification | TaskJSON | ParentWBSCode | LegacyTaskId | WorkZones | ScopeObjectIds | WorkQuantity | WorkQuantityUnit | Status | CalculationJSON | PlannedNetWorkHours | Planned8HourCrewDays | SetupHours | TravelAllowanceHours | ResourceBundleJSON | EquipmentRequirement | IncludedWork | PrimaryCode | Title | Clauses | RelatedCodes | ApplicationNote | SourceURL
관로·집수정 굴착 / C구역 | P2 작업 C_trench / 작업량 4.3625 m3 | PK.20.10.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / trench | CONSTRUCTION | PK.20.10.C 관로·집수정 굴착 / C구역 (관로·집수정 굴착); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "C_trench", "wbs_code": "PK.20.10.C", "zone_id": "C", "activity_type": "trench", "input_object_ids": ["ZONE_C"], "output_object_ids": [], "quantity": 4.3625, "unit": "m3", "predecessors": ["SITE_survey"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 4, "productivity_unit": "m3/crew_hour", "productivity_model_id": "trench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "20", "parent_wbs_code": "PK.20.10", "wbs_name": "관로·집수정 굴착 / C구역", "task_guid": "3nDxESg1nV2esLD9_Z00Ou", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_survey": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.090625, "planned_8h_crew_days": 0.136328125, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.10 | C_trench | C | ["ZONE_C"] | 4.3625 | m3 | ASSUMED_NOT_VERIFIED | [] | 1.09062 | 0.136328 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.2.1 준비배수; 3.3.1 땅깎기 | KCS 34 50 65 | 관로·집수정 굴착의 토공 기준. 흙막이 등은 지반·굴착 상세 확정 후 추가 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
되메우기·다짐 / C구역 | P2 작업 C_backfill / 작업량 2.894361 m3 | PK.20.50.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / backfill | CONSTRUCTION | PK.20.50.C 되메우기·다짐 / C구역 (되메우기·다짐); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "C_backfill", "wbs_code": "PK.20.50.C", "zone_id": "C", "activity_type": "backfill", "input_object_ids": ["ZONE_C"], "output_object_ids": [], "quantity": 2.8943606533614172, "unit": "m3", "predecessors": ["SITE_draincheck"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 6, "productivity_unit": "m3/crew_hour", "productivity_model_id": "backfill_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "24", "parent_wbs_code": "PK.20.50", "wbs_name": "되메우기·다짐 / C구역", "task_guid": "1r0fUENpbL7O6nViXdNDBw", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_draincheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.4823934422269029, "planned_8h_crew_days": 0.06029918027836286, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.50 | C_backfill | C | ["ZONE_C"] | 2.89436 | m3 | ASSUMED_NOT_VERIFIED | [] | 0.482393 | 0.0602992 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.3.3 흙쌓기; 3.6.3 다짐도 검사 | KCS 34 50 65 | 관로 검사 후 되메우기·다짐. 매설 완료 후 접속부 확인·승인도 필요하다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
휴게시설 기초 / C구역 | P2 작업 C_foundation / 작업량 0.153691 m3 | PK.30.10.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / foundation | CONSTRUCTION | PK.30.10.C 휴게시설 기초 / C구역 (휴게시설 기초); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "C_foundation", "wbs_code": "PK.30.10.C", "zone_id": "C", "activity_type": "foundation", "input_object_ids": ["BENCH06"], "output_object_ids": [], "quantity": 0.15369087603675097, "unit": "m3", "predecessors": ["C_backfill"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 1.5, "productivity_unit": "m3/crew_hour", "productivity_model_id": "foundation_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "30", "parent_wbs_code": "PK.30.10", "wbs_name": "휴게시설 기초 / C구역", "task_guid": "3MzvogOPfP49hPGElBmD2e", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_backfill": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.10246058402450064, "planned_8h_crew_days": 0.01280757300306258, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.30.10 | C_foundation | C | ["ZONE_C"] | 0.153691 | m3 | ASSUMED_NOT_VERIFIED | [] | 0.102461 | 0.0128076 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 05 | 조경시설물공통 | 3.2.1 토공; 3.2.2 기초; 3.2.5 콘크리트 공사 | KCS 34 50 20 | 벤치·퍼걸러 기초. 콘크리트 강도·양생·앵커 상세는 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2005%3A2024-12-10
식재기반 정비 / C구역 | P2 작업 C_soil / 작업량 393.5225 m2 | PK.50.20.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / soil | CONSTRUCTION | PK.50.20.C 식재기반 정비 / C구역 (식재기반 정비); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서) | {"task_id": "C_soil", "wbs_code": "PK.50.20.C", "zone_id": "C", "activity_type": "soil", "input_object_ids": ["green_C", "lawn_C"], "output_object_ids": ["shrub_C"], "quantity": 393.52250000000004, "unit": "m2", "predecessors": ["C_curb"], "lag": 0, "required_resource_bundle": {"excavator": 1, "crew_landscaper": 1, "crew_general": 2}, "productivity": 45, "productivity_unit": "m2/crew_hour", "productivity_model_id": "soil_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "32", "parent_wbs_code": "PK.50.20", "wbs_name": "식재기반 정비 / C구역", "task_guid": "3phl_q9RzUouelbUOY22gM", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_curb": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 8.744944444444446, "planned_8h_crew_days": 1.0931180555555557, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.50.20 | C_soil | C | ["ZONE_C"] | 393.523 | m2 | ASSUMED_NOT_VERIFIED | [] | 8.74494 | 1.09312 | 0.2 | 0.1 | {"excavator": 1, "crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 30 10 | 식재기반 조성 | 2.1 토양 관련 재료; 3.1.1 일반식재기반 조성 | KCS 34 20 10; KCS 34 40 05 | 식재용 토양·유효토심·배수 기반 검토. 토양 시험 및 현장 적합성은 미확인이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2030%2010%3A2024-12-10
교목 식재(구덩이 포함) / C구역 | P2 작업 C_trees / 작업량 2 ea | PK.50.30.C | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / trees | INSTALLATION | PK.50.30.C 교목 식재(구덩이 포함) / C구역 (교목 식재(구덩이 포함)); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "C_trees", "wbs_code": "PK.50.30.C", "zone_id": "C", "activity_type": "trees", "input_object_ids": [], "output_object_ids": ["P2_I01", "P2_N01"], "quantity": 2, "unit": "ea", "predecessors": ["C_soil"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1, "excavator": 1}, "productivity": 1.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 16, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "33", "parent_wbs_code": "PK.50.30", "wbs_name": "교목 식재(구덩이 포함) / C구역", "task_guid": "2fkikDmWfJ1vR$Sq8fBH35", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"C_soil": 0}, "included_pit_volume_m3": 1.01937825942743, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152"], "norm_breakdown": [{"rate_key": "TREE_I", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}], "norm_work_hours": 1.3333333333333333, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제", "planned_net_work_hours": 1.3333333333333333, "planned_8h_crew_days": 0.16666666666666666, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.50.30 | C_trees | C | ["ZONE_C"] | 2 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "TREE_I", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}] | 1.33333 | 0.166667 | 0 | 0.1 | {"crew_landscaper": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.5 지주세우기; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 신규 교목의 굴착·식재·지주·관수. 규격·분 상태·식재시기를 함께 확인한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152; NetCrewHours: 1.33333
화강석 경계석 설치 / C구역 | P2 작업 C_curb / 작업량 70.0 m | PK.30.20.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / curb | INSTALLATION | PK.30.20.C 화강석 경계석 설치 / C구역 (화강석 경계석 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "C_curb", "wbs_code": "PK.30.20.C", "zone_id": "C", "activity_type": "curb", "input_object_ids": [], "output_object_ids": ["CURB_C"], "quantity": 70.0, "unit": "m", "predecessors": ["C_backfill", "C_foundation"], "lag": 0, "required_resource_bundle": {"crew_special": 3, "crew_general": 1, "excavator": 1}, "productivity": 16.25, "productivity_unit": "m/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "39", "parent_wbs_code": "PK.30.20", "wbs_name": "화강석 경계석 설치 / C구역", "task_guid": "0$9KHyMNTPFwSkfydDXBB$", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"C_backfill": 0, "C_foundation": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385"], "norm_breakdown": [{"rate_key": "CURB_A", "quantity": 70.0, "daily_output": 130, "hours": 4.3076923076923075, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 4.3076923076923075, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 4.3076923076923075, "planned_8h_crew_days": 0.5384615384615384, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.30.20 | C_curb | C | ["ZONE_C"] | 70 | m | 2026_NORM_CONDITIONAL | [{"rate_key": "CURB_A", "quantity": 70.0, "daily_output": 130, "hours": 4.3076923076923075, "status": "CONDITIONAL_SITE"}] | 4.30769 | 0.538462 | 0 | 0.1 | {"crew_special": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 25 | 조경포장경계 | 3.1.1 토공 및 기초; 3.1.2 경계블록 | KCS 34 60 05; KCS 34 50 05 | 화강석 경계석 선형·높이·기초·줄눈·뒤채움. 기초 콘크리트 물량과 강도 확보 대기는 현재 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2025%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385; NetCrewHours: 4.30769
쇄석 포장기층 / C구역 | P2 작업 C_subbase / 작업량 96.0 m2 | PK.40.10.C | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / subbase | CONSTRUCTION | PK.40.10.C 쇄석 포장기층 / C구역 (쇄석 포장기층); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "C_subbase", "wbs_code": "PK.40.10.C", "zone_id": "C", "activity_type": "subbase", "input_object_ids": ["plaza_C", "walkway_C"], "output_object_ids": [], "quantity": 96.0, "unit": "m2", "predecessors": ["C_curb", "C_trees"], "lag": 0, "required_resource_bundle": {"crew_paver": 2, "crew_special": 2, "crew_general": 1}, "productivity": 18, "productivity_unit": "m2/crew_hour", "productivity_model_id": "subbase_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "40", "parent_wbs_code": "PK.40.10", "wbs_name": "쇄석 포장기층 / C구역", "task_guid": "28ZYQISCHUhR9PyPT7JVT2", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_curb": 0, "C_trees": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정.", "planned_net_work_hours": 5.333333333333333, "planned_8h_crew_days": 0.6666666666666666, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.40.10 | C_subbase | C | ["ZONE_C"] | 96 | m2 | ASSUMED_NOT_VERIFIED | [] | 5.33333 | 0.666667 | 0.2 | 0.1 | {"crew_paver": 2, "crew_special": 2, "crew_general": 1} | 기존 합성모델 장비 가정 | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. | KCS 34 60 05 | 조경포장공통 | 3.3.3 원지반 정지 및 다짐; 3.3.4 쇄석기층 | KCS 34 60 15 | 블록포장 하부의 쇄석기층. 두께·다짐도·계획고를 검측한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
포장 기층 검사 / C구역 | P2 작업 C_pavecheck / 작업량 1 ea | PK.40.20.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / pavecheck | INSPECTION | PK.40.20.C 포장 기층 검사 / C구역 (포장 기층 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "C_pavecheck", "wbs_code": "PK.40.20.C", "zone_id": "C", "activity_type": "pavecheck", "input_object_ids": ["plaza_C", "walkway_C"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["C_subbase"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 2, "productivity_unit": "ea/crew_hour", "productivity_model_id": "pavecheck_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "41", "parent_wbs_code": "PK.40.20", "wbs_name": "포장 기층 검사 / C구역", "task_guid": "3tcJijSsfR58MsDa6mzsFa", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_subbase": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.5, "planned_8h_crew_days": 0.0625, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.40.20 | C_pavecheck | C | ["ZONE_C"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 0.5 | 0.0625 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 05 | 조경포장공통 | 3.4 시공허용오차; 3.6 현장품질관리 | KCS 34 60 15; KCS 34 10 10 | 포장 기층 검사. 시험·검측을 통과했다는 의미가 아닌 기준 연결이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
모래·콘크리트블록 포장 / C구역 | P2 작업 C_finish / 작업량 96.0 m2 | PK.40.30.C | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / finish | CONSTRUCTION | PK.40.30.C 모래·콘크리트블록 포장 / C구역 (모래·콘크리트블록 포장); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "C_finish", "wbs_code": "PK.40.30.C", "zone_id": "C", "activity_type": "finish", "input_object_ids": [], "output_object_ids": ["plaza_C", "walkway_C"], "quantity": 96.0, "unit": "m2", "predecessors": ["C_pavecheck"], "lag": 0, "required_resource_bundle": {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1}, "productivity": 37.5, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": true, "closes": "C", "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "42", "parent_wbs_code": "PK.40.30", "wbs_name": "모래·콘크리트블록 포장 / C구역", "task_guid": "2ciU9Q1aXTmBj9GQHLSb_L", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"C_pavecheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374"], "norm_breakdown": [{"rate_key": "PAVING_A", "quantity": 96.0, "daily_output": 300, "hours": 2.56, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 2.56, "equipment_requirement": "굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "깔기모래·블록 절단 및 설치·줄눈채움·후다짐", "planned_net_work_hours": 2.56, "planned_8h_crew_days": 0.32, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.40.30 | C_finish | C | ["ZONE_C"] | 96 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "PAVING_A", "quantity": 96.0, "daily_output": 300, "hours": 2.56, "status": "CONDITIONAL_SITE"}] | 2.56 | 0.32 | 0 | 0.1 | {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1} | 굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대 | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 | KCS 34 60 15 | 친환경블록포장 | 2.1.1 소형고압블록; 3.2.2 소형고압블록포장 | KCS 34 60 05; KCS 34 60 25 | 200×200mm 콘크리트블록을 소형고압블록 계열로 잠정 매칭. 제품 KS·물성은 자재 승인 시 확정한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2015%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374; NetCrewHours: 2.56
관목 식재 / C구역 | P2 작업 C_shrubs / 작업량 181 ea | PK.50.40.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / shrubs | INSTALLATION | PK.50.40.C 관목 식재 / C구역 (관목 식재); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "C_shrubs", "wbs_code": "PK.50.40.C", "zone_id": "C", "activity_type": "shrubs", "input_object_ids": [], "output_object_ids": ["P2_B01-001", "P2_B01-002", "P2_B01-003", "P2_B01-004", "P2_B01-005", "P2_B01-006", "P2_B01-007", "P2_B01-008", "P2_B01-009", "P2_B01-010", "P2_B01-011", "P2_B01-012", "P2_B01-013", "P2_B01-014", "P2_B01-015", "P2_B01-016", "P2_B01-017", "P2_B01-018", "P2_B01-019", "P2_B01-020", "P2_B01-021", "P2_B01-022", "P2_B01-023", "P2_B01-024", "P2_B01-025", "P2_B01-026", "P2_B01-027", "P2_B01-028", "P2_B01-029", "P2_B01-030", "P2_B01-031", "P2_B01-032", "P2_B01-033", "P2_B01-034", "P2_B01-035", "P2_B01-036", "P2_B01-037", "P2_B01-038", "P2_B01-039", "P2_B01-040", "P2_B01-041", "P2_B01-042", "P2_B01-043", "P2_B01-044", "P2_B01-045", "P2_B01-046", "P2_B01-047", "P2_B01-048", "P2_B01-049", "P2_B01-050", "P2_B01-051", "P2_B01-052", "P2_B01-053", "P2_B01-054", "P2_B01-055", "P2_B01-056", "P2_B01-057", "P2_B01-058", "P2_B01-059", "P2_B01-060", "P2_B01-061", "P2_B01-062", "P2_B01-063", "P2_B01-064", "P2_B01-065", "P2_B01-066", "P2_B01-067", "P2_B01-068", "P2_B01-069", "P2_B01-070", "P2_B01-071", "P2_B01-072", "P2_B01-073", "P2_B01-074", "P2_B01-075", "P2_B01-076", "P2_B01-077", "P2_B01-078", "P2_B01-079", "P2_B01-080", "P2_B01-081", "P2_R01-001", "P2_R01-002", "P2_R01-003", "P2_R01-004", "P2_R01-005", "P2_R01-006", "P2_R01-007", "P2_R01-008", "P2_R01-009", "P2_R01-010", "P2_R01-011", "P2_R01-012", "P2_R01-013", "P2_R01-014", "P2_R01-015", "P2_R01-016", "P2_R01-017", "P2_R01-018", "P2_R01-019", "P2_R01-020", "P2_R01-021", "P2_R01-022", "P2_R01-023", "P2_R01-024", "P2_R01-025", "P2_R01-026", "P2_R01-027", "P2_R01-028", "P2_R01-029", "P2_R01-030", "P2_R01-031", "P2_R01-032", "P2_R01-033", "P2_R01-034", "P2_R01-035", "P2_R01-036", "P2_R01-037", "P2_R01-038", "P2_R01-039", "P2_R01-040", "P2_R01-041", "P2_R01-042", "P2_R01-043", "P2_R01-044", "P2_R01-045", "P2_R01-046", "P2_R01-047", "P2_Y01-001", "P2_Y01-002", "P2_Y01-003", "P2_Y01-004", "P2_Y01-005", "P2_Y01-006", "P2_Y01-007", "P2_Y01-008", "P2_Y01-009", "P2_Y01-010", "P2_Y01-011", "P2_Y01-012", "P2_Y01-013", "P2_Y01-014", "P2_Y01-015", "P2_Y01-016", "P2_Y01-017", "P2_Y01-018", "P2_Y01-019", "P2_Y01-020", "P2_Y01-021", "P2_Y01-022", "P2_Y01-023", "P2_Y01-024", "P2_Y01-025", "P2_Y01-026", "P2_Y01-027", "P2_Y01-028", "P2_Y03-001", "P2_Y03-002", "P2_Y03-003", "P2_Y03-004", "P2_Y03-005", "P2_Y03-006", "P2_Y03-007", "P2_Y03-008", "P2_Y03-009", "P2_Y03-010", "P2_Y03-011", "P2_Y03-012", "P2_Y03-013", "P2_Y03-014", "P2_Y03-015", "P2_Y03-016", "P2_Y03-017", "P2_Y03-018", "P2_Y03-019", "P2_Y03-020", "P2_Y03-021", "P2_Y03-022", "P2_Y03-023", "P2_Y03-024", "P2_Y03-025"], "quantity": 181, "unit": "ea", "predecessors": ["C_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1}, "productivity": 11.419078061911172, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "53", "parent_wbs_code": "PK.50.40", "wbs_name": "관목 식재 / C구역", "task_guid": "2hEwCNlHLLfwqMtDdNdGi_", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"C_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149"], "norm_breakdown": [{"rate_key": "SHRUB_B", "quantity": 81, "daily_output": 125, "hours": 5.184, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_R", "quantity": 47, "daily_output": 75, "hours": 5.013333333333334, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 53, "daily_output": 75, "hours": 5.653333333333333, "status": "SPEC_MATCHED"}], "norm_work_hours": 15.850666666666665, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 15.850666666666665, "planned_8h_crew_days": 1.9813333333333332, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.40 | C_shrubs | C | ["ZONE_C"] | 181 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "SHRUB_B", "quantity": 81, "daily_output": 125, "hours": 5.184, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_R", "quantity": 47, "daily_output": 75, "hours": 5.013333333333334, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 53, "daily_output": 75, "hours": 5.653333333333333, "status": "SPEC_MATCHED"}] | 15.8507 | 1.98133 | 0 | 0.03 | {"crew_landscaper": 3, "crew_general": 1} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 관목의 배식 간격·식재·관수. 품셈의 단식/군식 판정과 시방 적용은 서로 다른 정보이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149; NetCrewHours: 15.8507
평떼 잔디붙임 / C구역 | P2 작업 C_turf / 작업량 266.161425 m2 | PK.50.50.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / turf | INSTALLATION | PK.50.50.C 평떼 잔디붙임 / C구역 (평떼 잔디붙임); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 25 잔디식재 (KCS 조경공사 표준시방서) | {"task_id": "C_turf", "wbs_code": "PK.50.50.C", "zone_id": "C", "activity_type": "turf", "input_object_ids": [], "output_object_ids": ["lawn_C"], "quantity": 266.1614251909143, "unit": "m2", "predecessors": ["C_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 4}, "productivity": 18.75, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "54", "parent_wbs_code": "PK.50.50", "wbs_name": "평떼 잔디붙임 / C구역", "task_guid": "18Tkd5H2bNbfp2DnQiAhYt", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"C_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-1-1 잔디붙임 / 인쇄91 / PDF147"], "norm_breakdown": [{"rate_key": "TURF", "quantity": 266.1614251909143, "daily_output": 150, "hours": 14.195276010182097, "status": "CONDITIONAL_METHOD"}], "norm_work_hours": 14.195276010182097, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 14.195276010182097, "planned_8h_crew_days": 1.774409501272762, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.50 | C_turf | C | ["ZONE_C"] | 266.161 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "TURF", "quantity": 266.1614251909143, "daily_output": 150, "hours": 14.195276010182097, "status": "CONDITIONAL_METHOD"}] | 14.1953 | 1.77441 | 0 | 0.03 | {"crew_landscaper": 1, "crew_general": 4} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 25 | 잔디식재 | 2.1.1 잔디; 3.1.1 잔디식재 시공일반 | KCS 34 40 05; KCS 34 30 10 | 300×300mm 평떼 전면붙임. 반입 후 1일 이내 식재 조건을 고려한 반입 분할 계획은 아직 모델화하지 않았다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2025%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-1-1 잔디붙임 / 인쇄91 / PDF147; NetCrewHours: 14.1953
수목 하부 멀칭 / C구역 | P2 작업 C_mulch / 작업량 3.528617 m2 | PK.50.60.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / mulch | CONSTRUCTION | PK.50.60.C 수목 하부 멀칭 / C구역 (수목 하부 멀칭); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "C_mulch", "wbs_code": "PK.50.60.C", "zone_id": "C", "activity_type": "mulch", "input_object_ids": [], "output_object_ids": ["green_C"], "quantity": 3.52861705186418, "unit": "m2", "predecessors": ["C_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 25, "productivity_unit": "m2/crew_hour", "productivity_model_id": "mulch_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "55", "parent_wbs_code": "PK.50.60", "wbs_name": "수목 하부 멀칭 / C구역", "task_guid": "18HPlXDF9SXuOM7vaDyxua", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.1411446820745672, "planned_8h_crew_days": 0.0176430852593209, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.50.60 | C_mulch | C | ["ZONE_C"] | 3.52862 | m2 | ASSUMED_NOT_VERIFIED | [] | 0.141145 | 0.0176431 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 2.2.1 멀칭재 | KCS 34 40 05 | 수목 하부 멀칭재 품질 기준. 두께·시공 범위는 설계 가정이며 해당 조항이 수치를 확정하지 않는다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10
벤치 설치 / C구역 | P2 작업 C_bench / 작업량 1 ea | PK.60.10.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / bench | INSTALLATION | PK.60.10.C 벤치 설치 / C구역 (벤치 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 15 현장제작설치 시설 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "C_bench", "wbs_code": "PK.60.10.C", "zone_id": "C", "activity_type": "bench", "input_object_ids": [], "output_object_ids": ["BENCH06"], "quantity": 1, "unit": "ea", "predecessors": ["C_foundation", "C_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 0.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "bench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 24, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "60", "parent_wbs_code": "PK.60.10", "wbs_name": "벤치 설치 / C구역", "task_guid": "2ZZuVLGG5HL9UR2dcuTRnL", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_foundation": 24.0, "C_finish": 0.0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 2.0, "planned_8h_crew_days": 0.25, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.60.10 | C_bench | C | ["ZONE_C"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 2 | 0.25 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 20 | 옥외시설물 | 2.1.11 옥외용 벤치; 3.2.2 의자 | KCS 34 50 05; KCS 34 50 15 | 벤치 높이·기초·앵커·체결·마감 확인. 재료별 관련 시방을 함께 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2020%3A2024-12-10
구역 마무리 검사 / C구역 | P2 작업 C_check / 작업량 1 ea | PK.70.10.C | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / check | INSPECTION | PK.70.10.C 구역 마무리 검사 / C구역 (구역 마무리 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "C_check", "wbs_code": "PK.70.10.C", "zone_id": "C", "activity_type": "check", "input_object_ids": ["BENCH06", "CHAMBER_C", "CURB_C", "P2_B01-001", "P2_B01-002", "P2_B01-003", "P2_B01-004", "P2_B01-005", "P2_B01-006", "P2_B01-007", "P2_B01-008", "P2_B01-009", "P2_B01-010", "P2_B01-011", "P2_B01-012", "P2_B01-013", "P2_B01-014", "P2_B01-015", "P2_B01-016", "P2_B01-017", "P2_B01-018", "P2_B01-019", "P2_B01-020", "P2_B01-021", "P2_B01-022", "P2_B01-023", "P2_B01-024", "P2_B01-025", "P2_B01-026", "P2_B01-027", "P2_B01-028", "P2_B01-029", "P2_B01-030", "P2_B01-031", "P2_B01-032", "P2_B01-033", "P2_B01-034", "P2_B01-035", "P2_B01-036", "P2_B01-037", "P2_B01-038", "P2_B01-039", "P2_B01-040", "P2_B01-041", "P2_B01-042", "P2_B01-043", "P2_B01-044", "P2_B01-045", "P2_B01-046", "P2_B01-047", "P2_B01-048", "P2_B01-049", "P2_B01-050", "P2_B01-051", "P2_B01-052", "P2_B01-053", "P2_B01-054", "P2_B01-055", "P2_B01-056", "P2_B01-057", "P2_B01-058", "P2_B01-059", "P2_B01-060", "P2_B01-061", "P2_B01-062", "P2_B01-063", "P2_B01-064", "P2_B01-065", "P2_B01-066", "P2_B01-067", "P2_B01-068", "P2_B01-069", "P2_B01-070", "P2_B01-071", "P2_B01-072", "P2_B01-073", "P2_B01-074", "P2_B01-075", "P2_B01-076", "P2_B01-077", "P2_B01-078", "P2_B01-079", "P2_B01-080", "P2_B01-081", "P2_I01", "P2_N01", "P2_R01-001", "P2_R01-002", "P2_R01-003", "P2_R01-004", "P2_R01-005", "P2_R01-006", "P2_R01-007", "P2_R01-008", "P2_R01-009", "P2_R01-010", "P2_R01-011", "P2_R01-012", "P2_R01-013", "P2_R01-014", "P2_R01-015", "P2_R01-016", "P2_R01-017", "P2_R01-018", "P2_R01-019", "P2_R01-020", "P2_R01-021", "P2_R01-022", "P2_R01-023", "P2_R01-024", "P2_R01-025", "P2_R01-026", "P2_R01-027", "P2_R01-028", "P2_R01-029", "P2_R01-030", "P2_R01-031", "P2_R01-032", "P2_R01-033", "P2_R01-034", "P2_R01-035", "P2_R01-036", "P2_R01-037", "P2_R01-038", "P2_R01-039", "P2_R01-040", "P2_R01-041", "P2_R01-042", "P2_R01-043", "P2_R01-044", "P2_R01-045", "P2_R01-046", "P2_R01-047", "P2_Y01-001", "P2_Y01-002", "P2_Y01-003", "P2_Y01-004", "P2_Y01-005", "P2_Y01-006", "P2_Y01-007", "P2_Y01-008", "P2_Y01-009", "P2_Y01-010", "P2_Y01-011", "P2_Y01-012", "P2_Y01-013", "P2_Y01-014", "P2_Y01-015", "P2_Y01-016", "P2_Y01-017", "P2_Y01-018", "P2_Y01-019", "P2_Y01-020", "P2_Y01-021", "P2_Y01-022", "P2_Y01-023", "P2_Y01-024", "P2_Y01-025", "P2_Y01-026", "P2_Y01-027", "P2_Y01-028", "P2_Y03-001", "P2_Y03-002", "P2_Y03-003", "P2_Y03-004", "P2_Y03-005", "P2_Y03-006", "P2_Y03-007", "P2_Y03-008", "P2_Y03-009", "P2_Y03-010", "P2_Y03-011", "P2_Y03-012", "P2_Y03-013", "P2_Y03-014", "P2_Y03-015", "P2_Y03-016", "P2_Y03-017", "P2_Y03-018", "P2_Y03-019", "P2_Y03-020", "P2_Y03-021", "P2_Y03-022", "P2_Y03-023", "P2_Y03-024", "P2_Y03-025", "PIPE_C", "green_C", "lawn_C", "plaza_C", "shrub_C", "walkway_C"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["C_shrubs", "C_turf", "C_mulch", "C_bench"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 1, "productivity_unit": "ea/crew_hour", "productivity_model_id": "check_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_C", "work_zones": ["C"], "access_node_id": "C", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "70", "parent_wbs_code": "PK.70.10", "wbs_name": "구역 마무리 검사 / C구역", "task_guid": "0TLh3R24LJzPazNU4Uoi5b", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_C"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"C_shrubs": 0, "C_turf": 0, "C_mulch": 0, "C_bench": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.0, "planned_8h_crew_days": 0.125, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.10 | C_check | C | ["ZONE_C"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 1 | 0.125 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.6.2 품질시험·검사; 3.1.1 시공 확인 및 검사 | KCS 34 40 05; KCS 34 60 05; KCS 34 50 05 | 구역 종합검사 공통 기준. 해당 구역의 식재·포장·시설물 세부 기준을 함께 대조한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
관로·집수정 굴착 / D구역 | P2 작업 D_trench / 작업량 12.1625 m3 | PK.20.10.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / trench | CONSTRUCTION | PK.20.10.D 관로·집수정 굴착 / D구역 (관로·집수정 굴착); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "D_trench", "wbs_code": "PK.20.10.D", "zone_id": "D", "activity_type": "trench", "input_object_ids": ["ZONE_D"], "output_object_ids": [], "quantity": 12.1625, "unit": "m3", "predecessors": ["SITE_survey"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 4, "productivity_unit": "m3/crew_hour", "productivity_model_id": "trench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "20", "parent_wbs_code": "PK.20.10", "wbs_name": "관로·집수정 굴착 / D구역", "task_guid": "3OJwMFDGDPRRu_rQF61JFL", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_survey": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 3.040625, "planned_8h_crew_days": 0.380078125, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.10 | D_trench | D | ["ZONE_D"] | 12.1625 | m3 | ASSUMED_NOT_VERIFIED | [] | 3.04062 | 0.380078 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.2.1 준비배수; 3.3.1 땅깎기 | KCS 34 50 65 | 관로·집수정 굴착의 토공 기준. 흙막이 등은 지반·굴착 상세 확정 후 추가 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
되메우기·다짐 / D구역 | P2 작업 D_backfill / 작업량 8.582042 m3 | PK.20.50.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / backfill | CONSTRUCTION | PK.20.50.D 되메우기·다짐 / D구역 (되메우기·다짐); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "D_backfill", "wbs_code": "PK.20.50.D", "zone_id": "D", "activity_type": "backfill", "input_object_ids": ["ZONE_D"], "output_object_ids": [], "quantity": 8.58204214675894, "unit": "m3", "predecessors": ["SITE_draincheck"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 6, "productivity_unit": "m3/crew_hour", "productivity_model_id": "backfill_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "24", "parent_wbs_code": "PK.20.50", "wbs_name": "되메우기·다짐 / D구역", "task_guid": "2RyHpbymTUXgigqCmoLPK4", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_draincheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.4303403577931568, "planned_8h_crew_days": 0.1787925447241446, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.20.50 | D_backfill | D | ["ZONE_D"] | 8.58204 | m3 | ASSUMED_NOT_VERIFIED | [] | 1.43034 | 0.178793 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.3.3 흙쌓기; 3.6.3 다짐도 검사 | KCS 34 50 65 | 관로 검사 후 되메우기·다짐. 매설 완료 후 접속부 확인·승인도 필요하다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
휴게시설 기초 / D구역 | P2 작업 D_foundation / 작업량 2.093802 m3 | PK.30.10.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / foundation | CONSTRUCTION | PK.30.10.D 휴게시설 기초 / D구역 (휴게시설 기초); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "D_foundation", "wbs_code": "PK.30.10.D", "zone_id": "D", "activity_type": "foundation", "input_object_ids": ["BENCH01", "BENCH02", "PERGOLA01"], "output_object_ids": [], "quantity": 2.0938020104515593, "unit": "m3", "predecessors": ["D_backfill"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 1.5, "productivity_unit": "m3/crew_hour", "productivity_model_id": "foundation_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "30", "parent_wbs_code": "PK.30.10", "wbs_name": "휴게시설 기초 / D구역", "task_guid": "3eeK9C23XMD84XUyOI3f1f", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_backfill": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.3958680069677063, "planned_8h_crew_days": 0.1744835008709633, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.30.10 | D_foundation | D | ["ZONE_D"] | 2.0938 | m3 | ASSUMED_NOT_VERIFIED | [] | 1.39587 | 0.174484 | 0.2 | 0.1 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 05 | 조경시설물공통 | 3.2.1 토공; 3.2.2 기초; 3.2.5 콘크리트 공사 | KCS 34 50 20 | 벤치·퍼걸러 기초. 콘크리트 강도·양생·앵커 상세는 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2005%3A2024-12-10
식재기반 정비 / D구역 | P2 작업 D_soil / 작업량 356.9225 m2 | PK.50.20.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / soil | CONSTRUCTION | PK.50.20.D 식재기반 정비 / D구역 (식재기반 정비); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서) | {"task_id": "D_soil", "wbs_code": "PK.50.20.D", "zone_id": "D", "activity_type": "soil", "input_object_ids": ["green_D", "lawn_D"], "output_object_ids": ["shrub_D"], "quantity": 356.9225, "unit": "m2", "predecessors": ["D_curb"], "lag": 0, "required_resource_bundle": {"excavator": 1, "crew_landscaper": 1, "crew_general": 2}, "productivity": 45, "productivity_unit": "m2/crew_hour", "productivity_model_id": "soil_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "32", "parent_wbs_code": "PK.50.20", "wbs_name": "식재기반 정비 / D구역", "task_guid": "13wPMcmMfMEgX3OeQq2Yv5", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"D_curb": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 7.931611111111112, "planned_8h_crew_days": 0.991451388888889, "setup_hours": 0.2, "travel_allowance_hours": 0.1} | PK.50.20 | D_soil | D | ["ZONE_D"] | 356.923 | m2 | ASSUMED_NOT_VERIFIED | [] | 7.93161 | 0.991451 | 0.2 | 0.1 | {"excavator": 1, "crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 30 10 | 식재기반 조성 | 2.1 토양 관련 재료; 3.1.1 일반식재기반 조성 | KCS 34 20 10; KCS 34 40 05 | 식재용 토양·유효토심·배수 기반 검토. 토양 시험 및 현장 적합성은 미확인이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2030%2010%3A2024-12-10
교목 식재(구덩이 포함) / D구역 | P2 작업 D_trees / 작업량 4 ea | PK.50.30.D | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / trees | INSTALLATION | PK.50.30.D 교목 식재(구덩이 포함) / D구역 (교목 식재(구덩이 포함)); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "D_trees", "wbs_code": "PK.50.30.D", "zone_id": "D", "activity_type": "trees", "input_object_ids": [], "output_object_ids": ["P2_D03", "P2_I02", "P2_I03", "P2_I06"], "quantity": 4, "unit": "ea", "predecessors": ["D_soil"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1, "excavator": 1}, "productivity": 1.6923076923076923, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 16, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "33", "parent_wbs_code": "PK.50.30", "wbs_name": "교목 식재(구덩이 포함) / D구역", "task_guid": "1EdgMDHArHZvmYZkI7HuMq", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"D_soil": 0}, "included_pit_volume_m3": 2.038756518854861, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152"], "norm_breakdown": [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 3, "daily_output": 12, "hours": 2.0, "status": "SPEC_MATCHED"}], "norm_work_hours": 2.3636363636363638, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제", "planned_net_work_hours": 2.3636363636363638, "planned_8h_crew_days": 0.29545454545454547, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.50.30 | D_trees | D | ["ZONE_D"] | 4 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 3, "daily_output": 12, "hours": 2.0, "status": "SPEC_MATCHED"}] | 2.36364 | 0.295455 | 0 | 0.1 | {"crew_landscaper": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.5 지주세우기; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 신규 교목의 굴착·식재·지주·관수. 규격·분 상태·식재시기를 함께 확인한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152; NetCrewHours: 2.36364
화강석 경계석 설치 / D구역 | P2 작업 D_curb / 작업량 74.0 m | PK.30.20.D | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / curb | INSTALLATION | PK.30.20.D 화강석 경계석 설치 / D구역 (화강석 경계석 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "D_curb", "wbs_code": "PK.30.20.D", "zone_id": "D", "activity_type": "curb", "input_object_ids": [], "output_object_ids": ["CURB_D"], "quantity": 74.0, "unit": "m", "predecessors": ["D_backfill", "D_foundation"], "lag": 0, "required_resource_bundle": {"crew_special": 3, "crew_general": 1, "excavator": 1}, "productivity": 16.25, "productivity_unit": "m/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.1, "work_polygon_id": "ZONE_D", "work_zones": ["D"], "access_node_id": "D", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "39", "parent_wbs_code": "PK.30.20", "wbs_name": "화강석 경계석 설치 / D구역", "task_guid": "0DGSQDY45Gceiff83hevpq", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_D"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"D_backfill": 0, "D_foundation": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385"], "norm_breakdown": [{"rate_key": "CURB_A", "quantity": 74.0, "daily_output": 130, "hours": 4.553846153846154, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 4.553846153846154, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 4.553846153846154, "planned_8h_crew_days": 0.5692307692307692, "setup_hours": 0, "travel_allowance_hours": 0.1} | PK.30.20 | D_curb | D | ["ZONE_D"] | 74 | m | 2026_NORM_CONDITIONAL | [{"rate_key": "CURB_A", "quantity": 74.0, "daily_output": 130, "hours": 4.553846153846154, "status": "CONDITIONAL_SITE"}] | 4.55385 | 0.569231 | 0 | 0.1 | {"crew_special": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 25 | 조경포장경계 | 3.1.1 토공 및 기초; 3.1.2 경계블록 | KCS 34 60 05; KCS 34 50 05 | 화강석 경계석 선형·높이·기초·줄눈·뒤채움. 기초 콘크리트 물량과 강도 확보 대기는 현재 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2025%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385; NetCrewHours: 4.55385
