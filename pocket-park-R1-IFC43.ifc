Properties of the parts of a building model (IFC4X3_ADD2), part 5 of 9

# IfcGeographicElement: 조팝나무 H1.0 X W0.5 (177)
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_S01-021 | 관목 개체 / P2_S01-021 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-021 | B | {"type": "Point", "coordinates": [39.03018824728638, 28.0285338753896]} | 0.519061 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-022 | 관목 개체 / P2_S01-022 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-022 | B | {"type": "Point", "coordinates": [36.40518824728638, 28.678052928227928]} | 0.570127 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-023 | 관목 개체 / P2_S01-023 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-023 | B | {"type": "Point", "coordinates": [37.15518824728638, 28.678052928227928]} | 0.558877 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-024 | 관목 개체 / P2_S01-024 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-024 | B | {"type": "Point", "coordinates": [37.90518824728638, 28.678052928227928]} | 0.547627 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-025 | 관목 개체 / P2_S01-025 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-025 | B | {"type": "Point", "coordinates": [38.65518824728638, 28.678052928227928]} | 0.536377 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-026 | 관목 개체 / P2_S01-026 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-026 | B | {"type": "Point", "coordinates": [36.03018824728638, 29.327571981066257]} | 0.587443 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-027 | 관목 개체 / P2_S01-027 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-027 | B | {"type": "Point", "coordinates": [36.78018824728638, 29.327571981066257]} | 0.576193 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-028 | 관목 개체 / P2_S01-028 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-028 | B | {"type": "Point", "coordinates": [37.53018824728638, 29.327571981066257]} | 0.564943 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-029 | 관목 개체 / P2_S01-029 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-029 | B | {"type": "Point", "coordinates": [38.28018824728638, 29.327571981066257]} | 0.553693 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-030 | 관목 개체 / P2_S01-030 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-030 | B | {"type": "Point", "coordinates": [39.03018824728638, 29.327571981066257]} | 0.542443 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-031 | 관목 개체 / P2_S01-031 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-031 | B | {"type": "Point", "coordinates": [36.40518824728638, 29.977091033904586]} | 0.59351 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-032 | 관목 개체 / P2_S01-032 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-032 | B | {"type": "Point", "coordinates": [37.15518824728638, 29.977091033904586]} | 0.58226 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-033 | 관목 개체 / P2_S01-033 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-033 | B | {"type": "Point", "coordinates": [37.90518824728638, 29.977091033904586]} | 0.57101 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-034 | 관목 개체 / P2_S01-034 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-034 | B | {"type": "Point", "coordinates": [38.65518824728638, 29.977091033904586]} | 0.55976 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-035 | 관목 개체 / P2_S01-035 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-035 | B | {"type": "Point", "coordinates": [35.28018824728638, 30.626610086742915]} | 0.622076 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-036 | 관목 개체 / P2_S01-036 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-036 | B | {"type": "Point", "coordinates": [36.03018824728638, 30.626610086742915]} | 0.610826 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-037 | 관목 개체 / P2_S01-037 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-037 | B | {"type": "Point", "coordinates": [36.78018824728638, 30.626610086742915]} | 0.599576 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-038 | 관목 개체 / P2_S01-038 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-038 | B | {"type": "Point", "coordinates": [37.53018824728638, 30.626610086742915]} | 0.588326 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-039 | 관목 개체 / P2_S01-039 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-039 | B | {"type": "Point", "coordinates": [38.28018824728638, 30.626610086742915]} | 0.577076 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-040 | 관목 개체 / P2_S01-040 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-040 | B | {"type": "Point", "coordinates": [39.03018824728638, 30.626610086742915]} | 0.565826 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-041 | 관목 개체 / P2_S01-041 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-041 | B | {"type": "Point", "coordinates": [36.40518824728638, 31.276129139581244]} | 0.616893 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-042 | 관목 개체 / P2_S01-042 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-042 | B | {"type": "Point", "coordinates": [37.15518824728638, 31.276129139581244]} | 0.605643 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-043 | 관목 개체 / P2_S01-043 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-043 | B | {"type": "Point", "coordinates": [37.90518824728638, 31.276129139581244]} | 0.594393 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-044 | 관목 개체 / P2_S01-044 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-044 | B | {"type": "Point", "coordinates": [38.65518824728638, 31.276129139581244]} | 0.583143 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-045 | 관목 개체 / P2_S01-045 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-045 | B | {"type": "Point", "coordinates": [36.03018824728638, 31.925648192419573]} | 0.634209 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-046 | 관목 개체 / P2_S01-046 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-046 | B | {"type": "Point", "coordinates": [36.78018824728638, 31.925648192419573]} | 0.622959 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-047 | 관목 개체 / P2_S01-047 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-047 | B | {"type": "Point", "coordinates": [37.53018824728638, 31.925648192419573]} | 0.611709 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-048 | 관목 개체 / P2_S01-048 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-048 | B | {"type": "Point", "coordinates": [38.28018824728638, 31.925648192419573]} | 0.600459 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-049 | 관목 개체 / P2_S01-049 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-049 | B | {"type": "Point", "coordinates": [39.03018824728638, 31.925648192419573]} | 0.589209 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-050 | 관목 개체 / P2_S01-050 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-050 | B | {"type": "Point", "coordinates": [36.40518824728638, 32.5751672452579]} | 0.640275 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-051 | 관목 개체 / P2_S01-051 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-051 | B | {"type": "Point", "coordinates": [37.15518824728638, 32.5751672452579]} | 0.629025 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-052 | 관목 개체 / P2_S01-052 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-052 | B | {"type": "Point", "coordinates": [37.90518824728638, 32.5751672452579]} | 0.617775 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-053 | 관목 개체 / P2_S01-053 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-053 | B | {"type": "Point", "coordinates": [38.65518824728638, 32.5751672452579]} | 0.606525 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-054 | 관목 개체 / P2_S01-054 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-054 | B | {"type": "Point", "coordinates": [36.78018824728638, 33.22468629809623]} | 0.646342 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-055 | 관목 개체 / P2_S01-055 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-055 | B | {"type": "Point", "coordinates": [37.53018824728638, 33.22468629809623]} | 0.635092 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-056 | 관목 개체 / P2_S01-056 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-056 | B | {"type": "Point", "coordinates": [38.28018824728638, 33.22468629809623]} | 0.623842 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-057 | 관목 개체 / P2_S01-057 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-057 | B | {"type": "Point", "coordinates": [39.03018824728638, 33.22468629809623]} | 0.612592 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-058 | 관목 개체 / P2_S01-058 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-058 | B | {"type": "Point", "coordinates": [37.15518824728638, 33.87420535093456]} | 0.652408 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-059 | 관목 개체 / P2_S01-059 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-059 | B | {"type": "Point", "coordinates": [37.90518824728638, 33.87420535093456]} | 0.641158 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-060 | 관목 개체 / P2_S01-060 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-060 | B | {"type": "Point", "coordinates": [38.65518824728638, 33.87420535093456]} | 0.629908 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-061 | 관목 개체 / P2_S01-061 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-061 | B | {"type": "Point", "coordinates": [37.53018824728638, 34.52372440377289]} | 0.658474 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-062 | 관목 개체 / P2_S01-062 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-062 | B | {"type": "Point", "coordinates": [38.28018824728638, 34.52372440377289]} | 0.647224 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-063 | 관목 개체 / P2_S01-063 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-063 | B | {"type": "Point", "coordinates": [39.03018824728638, 34.52372440377289]} | 0.635974 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-064 | 관목 개체 / P2_S01-064 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-064 | B | {"type": "Point", "coordinates": [37.15518824728638, 35.17324345661122]} | 0.675791 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-065 | 관목 개체 / P2_S01-065 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-065 | B | {"type": "Point", "coordinates": [37.90518824728638, 35.17324345661122]} | 0.664541 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-066 | 관목 개체 / P2_S01-066 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-066 | B | {"type": "Point", "coordinates": [38.65518824728638, 35.17324345661122]} | 0.653291 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-067 | 관목 개체 / P2_S01-067 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-067 | B | {"type": "Point", "coordinates": [36.78018824728638, 35.82276250944955]} | 0.693107 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-068 | 관목 개체 / P2_S01-068 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-068 | B | {"type": "Point", "coordinates": [37.53018824728638, 35.82276250944955]} | 0.681857 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-069 | 관목 개체 / P2_S01-069 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-069 | B | {"type": "Point", "coordinates": [38.28018824728638, 35.82276250944955]} | 0.670607 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-070 | 관목 개체 / P2_S01-070 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-070 | B | {"type": "Point", "coordinates": [39.03018824728638, 35.82276250944955]} | 0.659357 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-071 | 관목 개체 / P2_S01-071 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-071 | B | {"type": "Point", "coordinates": [37.15518824728638, 36.472281562287876]} | 0.699173 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-072 | 관목 개체 / P2_S01-072 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-072 | B | {"type": "Point", "coordinates": [37.90518824728638, 36.472281562287876]} | 0.687923 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-073 | 관목 개체 / P2_S01-073 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-073 | B | {"type": "Point", "coordinates": [38.65518824728638, 36.472281562287876]} | 0.676673 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-074 | 관목 개체 / P2_S01-074 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-074 | B | {"type": "Point", "coordinates": [36.78018824728638, 37.121800615126205]} | 0.71649 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-075 | 관목 개체 / P2_S01-075 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-075 | B | {"type": "Point", "coordinates": [37.53018824728638, 37.121800615126205]} | 0.70524 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-076 | 관목 개체 / P2_S01-076 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-076 | B | {"type": "Point", "coordinates": [38.28018824728638, 37.121800615126205]} | 0.69399 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-077 | 관목 개체 / P2_S01-077 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-077 | B | {"type": "Point", "coordinates": [39.03018824728638, 37.121800615126205]} | 0.68274 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-078 | 관목 개체 / P2_S01-078 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-078 | B | {"type": "Point", "coordinates": [36.40518824728638, 37.77131966796453]} | 0.733806 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-079 | 관목 개체 / P2_S01-079 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-079 | B | {"type": "Point", "coordinates": [37.15518824728638, 37.77131966796453]} | 0.722556 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-080 | 관목 개체 / P2_S01-080 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-080 | B | {"type": "Point", "coordinates": [37.90518824728638, 37.77131966796453]} | 0.711306 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-081 | 관목 개체 / P2_S01-081 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-081 | B | {"type": "Point", "coordinates": [38.65518824728638, 37.77131966796453]} | 0.700056 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-082 | 관목 개체 / P2_S01-082 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-082 | B | {"type": "Point", "coordinates": [36.03018824728638, 38.42083872080286]} | 0.751122 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-083 | 관목 개체 / P2_S01-083 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-083 | B | {"type": "Point", "coordinates": [36.78018824728638, 38.42083872080286]} | 0.739872 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-084 | 관목 개체 / P2_S01-084 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-084 | B | {"type": "Point", "coordinates": [37.53018824728638, 38.42083872080286]} | 0.728622 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-085 | 관목 개체 / P2_S01-085 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-085 | B | {"type": "Point", "coordinates": [38.28018824728638, 38.42083872080286]} | 0.717372 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-086 | 관목 개체 / P2_S01-086 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-086 | B | {"type": "Point", "coordinates": [36.40518824728638, 39.07035777364119]} | 0.757189 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-087 | 관목 개체 / P2_S01-087 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-087 | B | {"type": "Point", "coordinates": [37.15518824728638, 39.07035777364119]} | 0.745939 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-088 | 관목 개체 / P2_S01-088 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-088 | B | {"type": "Point", "coordinates": [37.90518824728638, 39.07035777364119]} | 0.734689 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-089 | 관목 개체 / P2_S01-089 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-089 | B | {"type": "Point", "coordinates": [38.65518824728638, 39.07035777364119]} | 0.723439 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-090 | 관목 개체 / P2_S01-090 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-090 | B | {"type": "Point", "coordinates": [36.78018824728638, 39.71987682647952]} | 0.763255 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-091 | 관목 개체 / P2_S01-091 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-091 | B | {"type": "Point", "coordinates": [37.53018824728638, 39.71987682647952]} | 0.752005 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-092 | 관목 개체 / P2_S01-092 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-092 | B | {"type": "Point", "coordinates": [38.28018824728638, 39.71987682647952]} | 0.740755 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-093 | 관목 개체 / P2_S01-093 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-093 | B | {"type": "Point", "coordinates": [36.40518824728638, 40.36939587931785]} | 0.780571 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-094 | 관목 개체 / P2_S01-094 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-094 | B | {"type": "Point", "coordinates": [37.15518824728638, 40.36939587931785]} | 0.769321 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S01-095 | 관목 개체 / P2_S01-095 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S01-095 | B | {"type": "Point", "coordinates": [37.90518824728638, 40.36939587931785]} | 0.758071 | S01 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-001 | 관목 개체 / P2_S02-001 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-001 | B | {"type": "Point", "coordinates": [24.779375, 46.529999999999994]} | 1.06585 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-002 | 관목 개체 / P2_S02-002 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-002 | B | {"type": "Point", "coordinates": [25.529375, 46.529999999999994]} | 1.0546 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-003 | 관목 개체 / P2_S02-003 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-003 | B | {"type": "Point", "coordinates": [26.279375, 46.529999999999994]} | 1.04335 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-004 | 관목 개체 / P2_S02-004 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-004 | B | {"type": "Point", "coordinates": [27.029375, 46.529999999999994]} | 1.0321 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-005 | 관목 개체 / P2_S02-005 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-005 | A | {"type": "Point", "coordinates": [10.154375, 47.17951905283832]} | 1.29692 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-006 | 관목 개체 / P2_S02-006 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-006 | A | {"type": "Point", "coordinates": [10.904375, 47.17951905283832]} | 1.28567 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-007 | 관목 개체 / P2_S02-007 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-007 | A | {"type": "Point", "coordinates": [11.654375, 47.17951905283832]} | 1.27442 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-008 | 관목 개체 / P2_S02-008 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-008 | A | {"type": "Point", "coordinates": [12.404375, 47.17951905283832]} | 1.26317 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-009 | 관목 개체 / P2_S02-009 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-009 | A | {"type": "Point", "coordinates": [13.154375, 47.17951905283832]} | 1.25192 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-010 | 관목 개체 / P2_S02-010 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-010 | A | {"type": "Point", "coordinates": [13.904375, 47.17951905283832]} | 1.24067 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-011 | 관목 개체 / P2_S02-011 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-011 | A | {"type": "Point", "coordinates": [14.654375, 47.17951905283832]} | 1.22942 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-012 | 관목 개체 / P2_S02-012 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-012 | A | {"type": "Point", "coordinates": [15.404375, 47.17951905283832]} | 1.21817 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-013 | 관목 개체 / P2_S02-013 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-013 | A | {"type": "Point", "coordinates": [16.154375, 47.17951905283832]} | 1.20692 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-014 | 관목 개체 / P2_S02-014 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-014 | A | {"type": "Point", "coordinates": [16.904375, 47.17951905283832]} | 1.19567 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-015 | 관목 개체 / P2_S02-015 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-015 | B | {"type": "Point", "coordinates": [20.654375, 47.17951905283832]} | 1.13942 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-016 | 관목 개체 / P2_S02-016 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-016 | B | {"type": "Point", "coordinates": [21.404375, 47.17951905283832]} | 1.12817 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-017 | 관목 개체 / P2_S02-017 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-017 | B | {"type": "Point", "coordinates": [22.154375, 47.17951905283832]} | 1.11692 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-018 | 관목 개체 / P2_S02-018 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-018 | B | {"type": "Point", "coordinates": [24.404375, 47.17951905283832]} | 1.08317 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-019 | 관목 개체 / P2_S02-019 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-019 | B | {"type": "Point", "coordinates": [25.154375, 47.17951905283832]} | 1.07192 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-020 | 관목 개체 / P2_S02-020 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-020 | B | {"type": "Point", "coordinates": [25.904375, 47.17951905283832]} | 1.06067 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-021 | 관목 개체 / P2_S02-021 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-021 | B | {"type": "Point", "coordinates": [28.904375, 47.17951905283832]} | 1.01567 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-022 | 관목 개체 / P2_S02-022 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-022 | B | {"type": "Point", "coordinates": [29.654375, 47.17951905283832]} | 1.00442 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-023 | 관목 개체 / P2_S02-023 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-023 | B | {"type": "Point", "coordinates": [30.404375, 47.17951905283832]} | 0.993166 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-024 | 관목 개체 / P2_S02-024 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-024 | B | {"type": "Point", "coordinates": [32.654375, 47.17951905283832]} | 0.959416 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-025 | 관목 개체 / P2_S02-025 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-025 | B | {"type": "Point", "coordinates": [33.404375, 47.17951905283832]} | 0.948166 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-026 | 관목 개체 / P2_S02-026 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-026 | A | {"type": "Point", "coordinates": [8.279375, 47.82903810567665]} | 1.33673 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-027 | 관목 개체 / P2_S02-027 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-027 | A | {"type": "Point", "coordinates": [9.029375, 47.82903810567665]} | 1.32548 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-028 | 관목 개체 / P2_S02-028 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-028 | A | {"type": "Point", "coordinates": [9.779375, 47.82903810567665]} | 1.31423 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-029 | 관목 개체 / P2_S02-029 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-029 | A | {"type": "Point", "coordinates": [10.529375, 47.82903810567665]} | 1.30298 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-030 | 관목 개체 / P2_S02-030 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-030 | A | {"type": "Point", "coordinates": [11.279375, 47.82903810567665]} | 1.29173 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-031 | 관목 개체 / P2_S02-031 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-031 | A | {"type": "Point", "coordinates": [12.029375, 47.82903810567665]} | 1.28048 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-032 | 관목 개체 / P2_S02-032 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-032 | A | {"type": "Point", "coordinates": [12.779375, 47.82903810567665]} | 1.26923 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-033 | 관목 개체 / P2_S02-033 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-033 | A | {"type": "Point", "coordinates": [13.529375, 47.82903810567665]} | 1.25798 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-034 | 관목 개체 / P2_S02-034 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-034 | A | {"type": "Point", "coordinates": [14.279375, 47.82903810567665]} | 1.24673 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-035 | 관목 개체 / P2_S02-035 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-035 | A | {"type": "Point", "coordinates": [15.029375, 47.82903810567665]} | 1.23548 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-036 | 관목 개체 / P2_S02-036 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-036 | A | {"type": "Point", "coordinates": [15.779375, 47.82903810567665]} | 1.22423 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-037 | 관목 개체 / P2_S02-037 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-037 | A | {"type": "Point", "coordinates": [16.529375, 47.82903810567665]} | 1.21298 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-038 | 관목 개체 / P2_S02-038 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-038 | A | {"type": "Point", "coordinates": [17.279375, 47.82903810567665]} | 1.20173 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-039 | 관목 개체 / P2_S02-039 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-039 | A | {"type": "Point", "coordinates": [18.029375, 47.82903810567665]} | 1.19048 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-040 | 관목 개체 / P2_S02-040 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-040 | A | {"type": "Point", "coordinates": [18.779375, 47.82903810567665]} | 1.17923 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-041 | 관목 개체 / P2_S02-041 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-041 | A | {"type": "Point", "coordinates": [19.529375, 47.82903810567665]} | 1.16798 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-042 | 관목 개체 / P2_S02-042 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-042 | B | {"type": "Point", "coordinates": [20.279375, 47.82903810567665]} | 1.15673 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-043 | 관목 개체 / P2_S02-043 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-043 | B | {"type": "Point", "coordinates": [21.029375, 47.82903810567665]} | 1.14548 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-044 | 관목 개체 / P2_S02-044 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-044 | B | {"type": "Point", "coordinates": [21.779375, 47.82903810567665]} | 1.13423 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-045 | 관목 개체 / P2_S02-045 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-045 | B | {"type": "Point", "coordinates": [24.779375, 47.82903810567665]} | 1.08923 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-046 | 관목 개체 / P2_S02-046 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-046 | B | {"type": "Point", "coordinates": [25.529375, 47.82903810567665]} | 1.07798 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-047 | 관목 개체 / P2_S02-047 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-047 | B | {"type": "Point", "coordinates": [26.279375, 47.82903810567665]} | 1.06673 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-048 | 관목 개체 / P2_S02-048 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-048 | B | {"type": "Point", "coordinates": [28.529375, 47.82903810567665]} | 1.03298 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-049 | 관목 개체 / P2_S02-049 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-049 | B | {"type": "Point", "coordinates": [29.279375, 47.82903810567665]} | 1.02173 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-050 | 관목 개체 / P2_S02-050 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-050 | B | {"type": "Point", "coordinates": [30.029375, 47.82903810567665]} | 1.01048 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-051 | 관목 개체 / P2_S02-051 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-051 | B | {"type": "Point", "coordinates": [33.029375, 47.82903810567665]} | 0.965482 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-052 | 관목 개체 / P2_S02-052 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-052 | A | {"type": "Point", "coordinates": [8.654375, 48.47855715851498]} | 1.3428 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-053 | 관목 개체 / P2_S02-053 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-053 | A | {"type": "Point", "coordinates": [9.404375, 48.47855715851498]} | 1.33155 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-054 | 관목 개체 / P2_S02-054 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-054 | A | {"type": "Point", "coordinates": [10.154375, 48.47855715851498]} | 1.3203 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-055 | 관목 개체 / P2_S02-055 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-055 | A | {"type": "Point", "coordinates": [10.904375, 48.47855715851498]} | 1.30905 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-056 | 관목 개체 / P2_S02-056 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-056 | A | {"type": "Point", "coordinates": [11.654375, 48.47855715851498]} | 1.2978 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-057 | 관목 개체 / P2_S02-057 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-057 | A | {"type": "Point", "coordinates": [12.404375, 48.47855715851498]} | 1.28655 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-058 | 관목 개체 / P2_S02-058 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-058 | A | {"type": "Point", "coordinates": [13.154375, 48.47855715851498]} | 1.2753 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-059 | 관목 개체 / P2_S02-059 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-059 | A | {"type": "Point", "coordinates": [13.904375, 48.47855715851498]} | 1.26405 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-060 | 관목 개체 / P2_S02-060 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-060 | A | {"type": "Point", "coordinates": [14.654375, 48.47855715851498]} | 1.2528 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-061 | 관목 개체 / P2_S02-061 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-061 | A | {"type": "Point", "coordinates": [15.404375, 48.47855715851498]} | 1.24155 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-062 | 관목 개체 / P2_S02-062 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-062 | A | {"type": "Point", "coordinates": [16.154375, 48.47855715851498]} | 1.2303 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-063 | 관목 개체 / P2_S02-063 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-063 | A | {"type": "Point", "coordinates": [16.904375, 48.47855715851498]} | 1.21905 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-064 | 관목 개체 / P2_S02-064 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-064 | A | {"type": "Point", "coordinates": [17.654375, 48.47855715851498]} | 1.2078 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-065 | 관목 개체 / P2_S02-065 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-065 | A | {"type": "Point", "coordinates": [18.404375, 48.47855715851498]} | 1.19655 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-066 | 관목 개체 / P2_S02-066 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-066 | A | {"type": "Point", "coordinates": [19.154375, 48.47855715851498]} | 1.1853 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-067 | 관목 개체 / P2_S02-067 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_S02-067 | A | {"type": "Point", "coordinates": [19.904375, 48.47855715851498]} | 1.17405 | S02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_S02-068 | 관목 개체 / P2_S02-068 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-068 | B | {"type": "Point", "coordinates": [20.654375, 48.47855715851498]} | 1.1628 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-069 | 관목 개체 / P2_S02-069 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-069 | B | {"type": "Point", "coordinates": [21.404375, 48.47855715851498]} | 1.15155 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-070 | 관목 개체 / P2_S02-070 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-070 | B | {"type": "Point", "coordinates": [24.404375, 48.47855715851498]} | 1.10655 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-071 | 관목 개체 / P2_S02-071 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-071 | B | {"type": "Point", "coordinates": [25.154375, 48.47855715851498]} | 1.0953 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-072 | 관목 개체 / P2_S02-072 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-072 | B | {"type": "Point", "coordinates": [25.904375, 48.47855715851498]} | 1.08405 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-073 | 관목 개체 / P2_S02-073 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-073 | B | {"type": "Point", "coordinates": [26.654375, 48.47855715851498]} | 1.0728 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-074 | 관목 개체 / P2_S02-074 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-074 | B | {"type": "Point", "coordinates": [28.154375, 48.47855715851498]} | 1.0503 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-075 | 관목 개체 / P2_S02-075 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-075 | B | {"type": "Point", "coordinates": [28.904375, 48.47855715851498]} | 1.03905 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-076 | 관목 개체 / P2_S02-076 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-076 | B | {"type": "Point", "coordinates": [29.654375, 48.47855715851498]} | 1.0278 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-077 | 관목 개체 / P2_S02-077 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-077 | B | {"type": "Point", "coordinates": [30.404375, 48.47855715851498]} | 1.01655 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-078 | 관목 개체 / P2_S02-078 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-078 | B | {"type": "Point", "coordinates": [32.654375, 48.47855715851498]} | 0.982798 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-079 | 관목 개체 / P2_S02-079 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-079 | B | {"type": "Point", "coordinates": [28.529375, 49.12807621135331]} | 1.05636 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-080 | 관목 개체 / P2_S02-080 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-080 | B | {"type": "Point", "coordinates": [29.279375, 49.12807621135331]} | 1.04511 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-081 | 관목 개체 / P2_S02-081 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-081 | B | {"type": "Point", "coordinates": [30.029375, 49.12807621135331]} | 1.03386 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_S02-082 | 관목 개체 / P2_S02-082 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_S02-082 | B | {"type": "Point", "coordinates": [30.779375, 49.12807621135331]} | 1.02261 | S02 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs

# IfcGeographicElement: 주목 H3.0 X W1.5 (3)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 주목; NurserySpecification: H3.0 X W1.5; CrownWidthBasis: CATALOG
Classification: PK.50.30.B 교목 식재(구덩이 포함) / B구역 (교목 식재(구덩이 포함)); Group: 20 수목·녹지
LCS_Provenance - Kind: new_tree; Zone: B; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; PlantingRevision: P2; Height_m: 3; CrownWidth_m: 1.5; StemVisualizationDiameter_m: 0.08; StemDiameterBasis: ASSUMED_DISPLAY_ONLY; catalog R unspecified; CrownBaseDisplay_m: 0.25; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; TreeGeometry: Planting-stock envelope; species-specific source IFC geometry not copied
LCS_WBS - InventoryRole: NEW; PrimaryWBS: PK.50.30.B; WBSCodeList: PK.50.30.B;PK.70.10.B; LegacyTaskIds: B_check;B_trees; LinkedTaskCount: 2; ItemName: 주목; NurseryOrFacilitySpecification: H3.0 X W1.5; ClassificationVersion: R1-WBS2
Name | Description | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | GeometryJSON | ElevationMetre
P2_T01 | 주목 / H3.0 X W1.5 / P2_T01 | P2_T01 | {"type": "Point", "coordinates": [23.0, 48.0]} | 1.119
P2_T02 | 주목 / H3.0 X W1.5 / P2_T02 | P2_T02 | {"type": "Point", "coordinates": [27.5, 47.5]} | 1.0425
P2_T03 | 주목 / H3.0 X W1.5 / P2_T03 | P2_T03 | {"type": "Point", "coordinates": [31.5, 48.0]} | 0.9915

# IfcGeographicElement: 회양목 H0.4 X W0.5 (181)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 회양목; NurserySpecification: H0.4 X W0.5
LCS_Provenance - Kind: shrub_plant; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Height_m: 0.4; CrownWidth_m: 0.5; CenterSpacing_m: 0.55; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; Quantity: 1; GeometryBasis: Nursery H/W envelope; not mature crown
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 회양목; NurseryOrFacilitySpecification: H0.4 X W0.5; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_B01-001 | 관목 개체 / P2_B01-001 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-001 | C | {"type": "Point", "coordinates": [2.045, 1.3406889720814412]} | 0.593457 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-002 | 관목 개체 / P2_B01-002 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-002 | C | {"type": "Point", "coordinates": [2.5949999999999998, 1.3406889720814412]} | 0.585207 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-003 | 관목 개체 / P2_B01-003 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-003 | C | {"type": "Point", "coordinates": [3.1449999999999996, 1.3406889720814412]} | 0.576957 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-004 | 관목 개체 / P2_B01-004 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-004 | C | {"type": "Point", "coordinates": [3.6949999999999994, 1.3406889720814412]} | 0.568707 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-005 | 관목 개체 / P2_B01-005 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-005 | C | {"type": "Point", "coordinates": [4.244999999999999, 1.3406889720814412]} | 0.560457 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-006 | 관목 개체 / P2_B01-006 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-006 | C | {"type": "Point", "coordinates": [4.794999999999999, 1.3406889720814412]} | 0.552207 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-007 | 관목 개체 / P2_B01-007 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-007 | C | {"type": "Point", "coordinates": [5.344999999999999, 1.3406889720814412]} | 0.543957 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-008 | 관목 개체 / P2_B01-008 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-008 | C | {"type": "Point", "coordinates": [5.894999999999999, 1.3406889720814412]} | 0.535707 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-009 | 관목 개체 / P2_B01-009 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-009 | C | {"type": "Point", "coordinates": [6.4449999999999985, 1.3406889720814412]} | 0.527457 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-010 | 관목 개체 / P2_B01-010 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-010 | C | {"type": "Point", "coordinates": [6.994999999999998, 1.3406889720814412]} | 0.519207 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-011 | 관목 개체 / P2_B01-011 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-011 | C | {"type": "Point", "coordinates": [7.544999999999998, 1.3406889720814412]} | 0.510957 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-012 | 관목 개체 / P2_B01-012 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-012 | C | {"type": "Point", "coordinates": [8.094999999999999, 1.3406889720814412]} | 0.502707 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-013 | 관목 개체 / P2_B01-013 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-013 | C | {"type": "Point", "coordinates": [8.645, 1.3406889720814412]} | 0.494457 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-014 | 관목 개체 / P2_B01-014 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-014 | C | {"type": "Point", "coordinates": [9.195, 1.3406889720814412]} | 0.486207 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-015 | 관목 개체 / P2_B01-015 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-015 | C | {"type": "Point", "coordinates": [9.745000000000001, 1.3406889720814412]} | 0.477957 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-016 | 관목 개체 / P2_B01-016 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-016 | C | {"type": "Point", "coordinates": [10.295000000000002, 1.3406889720814412]} | 0.469707 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-017 | 관목 개체 / P2_B01-017 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-017 | C | {"type": "Point", "coordinates": [10.845000000000002, 1.3406889720814412]} | 0.461457 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-018 | 관목 개체 / P2_B01-018 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-018 | C | {"type": "Point", "coordinates": [11.395000000000003, 1.3406889720814412]} | 0.453207 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-019 | 관목 개체 / P2_B01-019 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-019 | C | {"type": "Point", "coordinates": [1.2200000000000002, 1.8170029441628825]} | 0.614406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-020 | 관목 개체 / P2_B01-020 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-020 | C | {"type": "Point", "coordinates": [1.7700000000000002, 1.8170029441628825]} | 0.606156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-021 | 관목 개체 / P2_B01-021 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-021 | C | {"type": "Point", "coordinates": [2.3200000000000003, 1.8170029441628825]} | 0.597906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-022 | 관목 개체 / P2_B01-022 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-022 | C | {"type": "Point", "coordinates": [2.87, 1.8170029441628825]} | 0.589656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-023 | 관목 개체 / P2_B01-023 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-023 | C | {"type": "Point", "coordinates": [3.42, 1.8170029441628825]} | 0.581406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-024 | 관목 개체 / P2_B01-024 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-024 | C | {"type": "Point", "coordinates": [3.9699999999999998, 1.8170029441628825]} | 0.573156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-025 | 관목 개체 / P2_B01-025 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-025 | C | {"type": "Point", "coordinates": [4.52, 1.8170029441628825]} | 0.564906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-026 | 관목 개체 / P2_B01-026 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-026 | C | {"type": "Point", "coordinates": [5.069999999999999, 1.8170029441628825]} | 0.556656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-027 | 관목 개체 / P2_B01-027 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-027 | C | {"type": "Point", "coordinates": [5.619999999999999, 1.8170029441628825]} | 0.548406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-028 | 관목 개체 / P2_B01-028 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-028 | C | {"type": "Point", "coordinates": [6.169999999999999, 1.8170029441628825]} | 0.540156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-029 | 관목 개체 / P2_B01-029 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-029 | C | {"type": "Point", "coordinates": [6.719999999999999, 1.8170029441628825]} | 0.531906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-030 | 관목 개체 / P2_B01-030 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-030 | C | {"type": "Point", "coordinates": [7.269999999999999, 1.8170029441628825]} | 0.523656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-031 | 관목 개체 / P2_B01-031 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-031 | C | {"type": "Point", "coordinates": [7.8199999999999985, 1.8170029441628825]} | 0.515406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-032 | 관목 개체 / P2_B01-032 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-032 | C | {"type": "Point", "coordinates": [8.37, 1.8170029441628825]} | 0.507156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-033 | 관목 개체 / P2_B01-033 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-033 | C | {"type": "Point", "coordinates": [8.92, 1.8170029441628825]} | 0.498906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-034 | 관목 개체 / P2_B01-034 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-034 | C | {"type": "Point", "coordinates": [9.47, 1.8170029441628825]} | 0.490656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-035 | 관목 개체 / P2_B01-035 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-035 | C | {"type": "Point", "coordinates": [10.020000000000001, 1.8170029441628825]} | 0.482406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-036 | 관목 개체 / P2_B01-036 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-036 | C | {"type": "Point", "coordinates": [10.570000000000002, 1.8170029441628825]} | 0.474156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-037 | 관목 개체 / P2_B01-037 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-037 | C | {"type": "Point", "coordinates": [11.120000000000003, 1.8170029441628825]} | 0.465906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-038 | 관목 개체 / P2_B01-038 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-038 | C | {"type": "Point", "coordinates": [11.670000000000003, 1.8170029441628825]} | 0.457656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-039 | 관목 개체 / P2_B01-039 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-039 | C | {"type": "Point", "coordinates": [12.220000000000004, 1.8170029441628825]} | 0.449406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-040 | 관목 개체 / P2_B01-040 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-040 | C | {"type": "Point", "coordinates": [12.770000000000005, 1.8170029441628825]} | 0.441156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-041 | 관목 개체 / P2_B01-041 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-041 | C | {"type": "Point", "coordinates": [13.320000000000006, 1.8170029441628825]} | 0.432906 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-042 | 관목 개체 / P2_B01-042 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-042 | C | {"type": "Point", "coordinates": [13.870000000000006, 1.8170029441628825]} | 0.424656 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-043 | 관목 개체 / P2_B01-043 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-043 | C | {"type": "Point", "coordinates": [14.420000000000007, 1.8170029441628825]} | 0.416406 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-044 | 관목 개체 / P2_B01-044 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-044 | C | {"type": "Point", "coordinates": [14.970000000000008, 1.8170029441628825]} | 0.408156 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-045 | 관목 개체 / P2_B01-045 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-045 | C | {"type": "Point", "coordinates": [0.9450000000000001, 2.293316916244324]} | 0.627105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-046 | 관목 개체 / P2_B01-046 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-046 | C | {"type": "Point", "coordinates": [1.495, 2.293316916244324]} | 0.618855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-047 | 관목 개체 / P2_B01-047 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-047 | C | {"type": "Point", "coordinates": [2.045, 2.293316916244324]} | 0.610605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-048 | 관목 개체 / P2_B01-048 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-048 | C | {"type": "Point", "coordinates": [2.5949999999999998, 2.293316916244324]} | 0.602355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-049 | 관목 개체 / P2_B01-049 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-049 | C | {"type": "Point", "coordinates": [3.1449999999999996, 2.293316916244324]} | 0.594105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-050 | 관목 개체 / P2_B01-050 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-050 | C | {"type": "Point", "coordinates": [3.6949999999999994, 2.293316916244324]} | 0.585855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-051 | 관목 개체 / P2_B01-051 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-051 | C | {"type": "Point", "coordinates": [4.244999999999999, 2.293316916244324]} | 0.577605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-052 | 관목 개체 / P2_B01-052 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-052 | C | {"type": "Point", "coordinates": [4.794999999999999, 2.293316916244324]} | 0.569355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-053 | 관목 개체 / P2_B01-053 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-053 | C | {"type": "Point", "coordinates": [5.344999999999999, 2.293316916244324]} | 0.561105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-054 | 관목 개체 / P2_B01-054 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-054 | C | {"type": "Point", "coordinates": [5.894999999999999, 2.293316916244324]} | 0.552855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-055 | 관목 개체 / P2_B01-055 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-055 | C | {"type": "Point", "coordinates": [6.4449999999999985, 2.293316916244324]} | 0.544605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-056 | 관목 개체 / P2_B01-056 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-056 | C | {"type": "Point", "coordinates": [6.994999999999998, 2.293316916244324]} | 0.536355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-057 | 관목 개체 / P2_B01-057 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-057 | C | {"type": "Point", "coordinates": [7.544999999999998, 2.293316916244324]} | 0.528105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-058 | 관목 개체 / P2_B01-058 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-058 | C | {"type": "Point", "coordinates": [8.094999999999999, 2.293316916244324]} | 0.519855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-059 | 관목 개체 / P2_B01-059 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-059 | C | {"type": "Point", "coordinates": [8.645, 2.293316916244324]} | 0.511605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-060 | 관목 개체 / P2_B01-060 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-060 | C | {"type": "Point", "coordinates": [9.195, 2.293316916244324]} | 0.503355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-061 | 관목 개체 / P2_B01-061 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-061 | C | {"type": "Point", "coordinates": [10.845000000000002, 2.293316916244324]} | 0.478605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-062 | 관목 개체 / P2_B01-062 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-062 | C | {"type": "Point", "coordinates": [11.395000000000003, 2.293316916244324]} | 0.470355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-063 | 관목 개체 / P2_B01-063 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-063 | C | {"type": "Point", "coordinates": [11.945000000000004, 2.293316916244324]} | 0.462105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-064 | 관목 개체 / P2_B01-064 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-064 | C | {"type": "Point", "coordinates": [12.495000000000005, 2.293316916244324]} | 0.453855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-065 | 관목 개체 / P2_B01-065 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-065 | C | {"type": "Point", "coordinates": [13.045000000000005, 2.293316916244324]} | 0.445605 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-066 | 관목 개체 / P2_B01-066 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-066 | C | {"type": "Point", "coordinates": [13.595000000000006, 2.293316916244324]} | 0.437355 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-067 | 관목 개체 / P2_B01-067 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-067 | C | {"type": "Point", "coordinates": [14.145000000000007, 2.293316916244324]} | 0.429105 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-068 | 관목 개체 / P2_B01-068 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-068 | C | {"type": "Point", "coordinates": [14.695000000000007, 2.293316916244324]} | 0.420855 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-069 | 관목 개체 / P2_B01-069 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-069 | C | {"type": "Point", "coordinates": [1.2200000000000002, 2.769630888325765]} | 0.631553 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-070 | 관목 개체 / P2_B01-070 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-070 | C | {"type": "Point", "coordinates": [1.7700000000000002, 2.769630888325765]} | 0.623303 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-071 | 관목 개체 / P2_B01-071 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-071 | C | {"type": "Point", "coordinates": [2.3200000000000003, 2.769630888325765]} | 0.615053 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-072 | 관목 개체 / P2_B01-072 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-072 | C | {"type": "Point", "coordinates": [2.87, 2.769630888325765]} | 0.606803 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-073 | 관목 개체 / P2_B01-073 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-073 | C | {"type": "Point", "coordinates": [3.42, 2.769630888325765]} | 0.598553 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-074 | 관목 개체 / P2_B01-074 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-074 | C | {"type": "Point", "coordinates": [3.9699999999999998, 2.769630888325765]} | 0.590303 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-075 | 관목 개체 / P2_B01-075 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-075 | C | {"type": "Point", "coordinates": [4.52, 2.769630888325765]} | 0.582053 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-076 | 관목 개체 / P2_B01-076 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-076 | C | {"type": "Point", "coordinates": [5.069999999999999, 2.769630888325765]} | 0.573803 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-077 | 관목 개체 / P2_B01-077 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-077 | C | {"type": "Point", "coordinates": [5.619999999999999, 2.769630888325765]} | 0.565553 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-078 | 관목 개체 / P2_B01-078 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-078 | C | {"type": "Point", "coordinates": [6.169999999999999, 2.769630888325765]} | 0.557303 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-079 | 관목 개체 / P2_B01-079 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-079 | C | {"type": "Point", "coordinates": [6.719999999999999, 2.769630888325765]} | 0.549053 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-080 | 관목 개체 / P2_B01-080 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-080 | C | {"type": "Point", "coordinates": [7.269999999999999, 2.769630888325765]} | 0.540803 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B01-081 | 관목 개체 / P2_B01-081 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_B01-081 | C | {"type": "Point", "coordinates": [7.8199999999999985, 2.769630888325765]} | 0.532553 | B01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_B02-001 | 관목 개체 / P2_B02-001 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-001 | D | {"type": "Point", "coordinates": [26.045, 1.3766264720814412]} | 0.234104 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-002 | 관목 개체 / P2_B02-002 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-002 | D | {"type": "Point", "coordinates": [26.595000000000002, 1.3766264720814412]} | 0.225854 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-003 | 관목 개체 / P2_B02-003 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-003 | D | {"type": "Point", "coordinates": [27.145000000000003, 1.3766264720814412]} | 0.217604 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-004 | 관목 개체 / P2_B02-004 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-004 | D | {"type": "Point", "coordinates": [27.695000000000004, 1.3766264720814412]} | 0.209354 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-005 | 관목 개체 / P2_B02-005 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-005 | D | {"type": "Point", "coordinates": [28.245000000000005, 1.3766264720814412]} | 0.201104 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-006 | 관목 개체 / P2_B02-006 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-006 | D | {"type": "Point", "coordinates": [28.795000000000005, 1.3766264720814412]} | 0.192854 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-007 | 관목 개체 / P2_B02-007 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-007 | D | {"type": "Point", "coordinates": [29.345000000000006, 1.3766264720814412]} | 0.184604 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-008 | 관목 개체 / P2_B02-008 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-008 | D | {"type": "Point", "coordinates": [29.895000000000007, 1.3766264720814412]} | 0.176354 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-009 | 관목 개체 / P2_B02-009 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-009 | D | {"type": "Point", "coordinates": [30.445000000000007, 1.3766264720814412]} | 0.168104 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-010 | 관목 개체 / P2_B02-010 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-010 | D | {"type": "Point", "coordinates": [30.995000000000008, 1.3766264720814412]} | 0.159854 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-011 | 관목 개체 / P2_B02-011 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-011 | D | {"type": "Point", "coordinates": [31.54500000000001, 1.3766264720814412]} | 0.151604 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-012 | 관목 개체 / P2_B02-012 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-012 | D | {"type": "Point", "coordinates": [32.095000000000006, 1.3766264720814412]} | 0.143354 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
P2_B02-013 | 관목 개체 / P2_B02-013 | PK.50.40.D 관목 식재 / D구역 (관목 식재) | P2_B02-013 | D | {"type": "Point", "coordinates": [32.645, 1.3766264720814412]} | 0.135104 | B02 | PK.50.40.D | PK.50.40.D;PK.70.10.D | D_check;D_shrubs
