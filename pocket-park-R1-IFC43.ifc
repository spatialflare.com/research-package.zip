Properties of the parts of a building model (IFC4X3_ADD2), part 3 of 9

# IfcGeographicElement (13)
Name | Description | PredefinedType | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Kind | Zone | GeometryJSON | ElevationMetre | cover (m2) | TopPlane | DisplayOffset_m | DisplayLayerThickness_m | QuantityBasis | InventoryRole | PrimaryWBS | WBSCodeList | LegacyTaskIds | LinkedTaskCount | ItemName | Group | MappingNote
green_B | 일반녹지 / green_B | VEGETATION | PK.50.60.B 수목 하부 멀칭 / B구역 (수목 하부 멀칭) | green_B | green | B | {"type": "MultiPolygon", "coordinates": [[[[27.416677674764703, 30.37639779077309], [27.3535475526195, 30.338559051738734], [27.287012574273817, 30.307090350616534], [27.217713507940847, 30.282294748200844], [27.146317741512096, 30.264411039697578], [27.07351285524717, 30.253611454995852], [27.0, 30.25], [26.92648714475283, 30.253611454995852], [26.853682258487904, 30.264411039697578], [26.782286492059153, 30.282294748200844], [26.712987425726183, 30.307090350616534], [26.6464524473805, 30.338559051738734], [26.583322325235297, 30.37639779077309], [26.524205036877266, 30.420242159977946], [26.46966991411009, 30.46966991411009], [26.420242159977946, 30.524205036877266], [26.37639779077309, 30.583322325235297], [26.338559051738734, 30.6464524473805], [26.307090350616534, 30.712987425726183], [26.282294748200844, 30.782286492059153], [26.264411039697578, 30.853682258487904], [26.253611454995852, 30.92648714475283], [26.25, 31.0], [26.253611454995852, 31.07351285524717], [26.264411039697578, 31.146317741512096], [26.282294748200844, 31.217713507940847], [26.307090350616534, 31.287012574273817], [26.338559051738734, 31.3535475526195], [26.37639779077309, 31.416677674764703], [26.420242159977946, 31.475794963122734], [26.46966991411009, 31.53033008588991], [26.524205036877266, 31.57975784002205], [26.583322325235297, 31.62360220922691], [26.6464524473805, 31.661440948261266], [26.712987425726183, 31.692909649383466], [26.782286492059153, 31.717705251799156], [26.853682258487904, 31.735588960302422], [26.92648714475283, 31.746388545004148], [27.0, 31.75], [27.07351285524717, 31.746388545004148], [27.146317741512096, 31.735588960302422], [27.217713507940847, 31.717705251799156], [27.287012574273817, 31.692909649383466], [27.3535475526195, 31.661440948261266], [27.416677674764703, 31.62360220922691], [27.475794963122734, 31.579757840022054], [27.53033008588991, 31.53033008588991], [27.57975784002205, 31.475794963122734], [27.62360220922691, 31.416677674764703], [27.661440948261266, 31.3535475526195], [27.692909649383466, 31.287012574273817], [27.717705251799156, 31.217713507940847], [27.735588960302422, 31.146317741512096], [27.746388545004148, 31.07351285524717], [27.75, 31.0], [27.746388545004148, 30.92648714475283], [27.735588960302422, 30.853682258487904], [27.717705251799156, 30.782286492059153], [27.692909649383466, 30.712987425726183], [27.661440948261266, 30.6464524473805], [27.62360220922691, 30.583322325235297], [27.579757840022054, 30.524205036877266], [27.53033008588991, 30.46966991411009], [27.475794963122734, 30.420242159977946], [27.416677674764703, 30.37639779077309]]], [[[26.8535475526195, 41.838559051738734], [26.787012574273817, 41.807090350616534], [26.717713507940847, 41.78229474820084], [26.646317741512096, 41.76441103969758], [26.57351285524717, 41.753611454995855], [26.5, 41.75], [26.42648714475283, 41.753611454995855], [26.353682258487904, 41.76441103969758], [26.282286492059153, 41.78229474820084], [26.212987425726183, 41.807090350616534], [26.1464524473805, 41.838559051738734], [26.083322325235297, 41.87639779077309], [26.024205036877266, 41.920242159977946], [25.96966991411009, 41.96966991411009], [25.920242159977946, 42.02420503687726], [25.87639779077309, 42.0833223252353], [25.838559051738734, 42.146452447380504], [25.807090350616534, 42.21298742572618], [25.782294748200844, 42.28228649205915], [25.764411039697578, 42.3536822584879], [25.753611454995852, 42.42648714475283], [25.75, 42.5], [25.753611454995852, 42.57351285524717], [25.764411039697578, 42.6463177415121], [25.782294748200844, 42.71771350794085], [25.807090350616534, 42.78701257427382], [25.838559051738734, 42.853547552619496], [25.87639779077309, 42.9166776747647], [25.920242159977946, 42.97579496312273], [25.96966991411009, 43.03033008588991], [26.024205036877266, 43.079757840022054], [26.083322325235297, 43.12360220922691], [26.1464524473805, 43.161440948261266], [26.212987425726183, 43.192909649383466], [26.282286492059153, 43.21770525179916], [26.353682258487904, 43.23558896030242], [26.42648714475283, 43.246388545004145], [26.5, 43.25], [26.57351285524717, 43.246388545004145], [26.646317741512096, 43.23558896030242], [26.717713507940847, 43.21770525179916], [26.787012574273817, 43.192909649383466], [26.8535475526195, 43.161440948261266], [26.916677674764703, 43.12360220922691], [26.975794963122734, 43.079757840022054], [27.03033008588991, 43.03033008588991], [27.07975784002205, 42.97579496312274], [27.12360220922691, 42.9166776747647], [27.161440948261266, 42.853547552619496], [27.192909649383466, 42.78701257427382], [27.217705251799156, 42.71771350794085], [27.235588960302422, 42.6463177415121], [27.246388545004148, 42.57351285524717], [27.25, 42.5], [27.246388545004148, 42.42648714475283], [27.235588960302422, 42.3536822584879], [27.217705251799156, 42.28228649205915], [27.192909649383466, 42.21298742572618], [27.161440948261266, 42.146452447380504], [27.12360220922691, 42.0833223252353], [27.079757840022054, 42.02420503687726], [27.03033008588991, 41.96966991411009], [26.975794963122734, 41.920242159977946], [26.916677674764703, 41.87639779077309], [26.8535475526195, 41.838559051738734]]], [[[37.353547552619496, 46.338559051738734], [37.28701257427382, 46.307090350616534], [37.21771350794085, 46.28229474820084], [37.1463177415121, 46.26441103969758], [37.07351285524717, 46.253611454995855], [37.0, 46.25], [36.92648714475283, 46.253611454995855], [36.8536822584879, 46.26441103969758], [36.78228649205915, 46.28229474820084], [36.71298742572618, 46.307090350616534], [36.646452447380504, 46.338559051738734], [36.5833223252353, 46.37639779077309], [36.52420503687726, 46.420242159977946], [36.46966991411009, 46.46966991411009], [36.420242159977946, 46.52420503687726], [36.37639779077309, 46.5833223252353], [36.338559051738734, 46.646452447380504], [36.307090350616534, 46.71298742572618], [36.28229474820084, 46.78228649205915], [36.26441103969758, 46.8536822584879], [36.253611454995855, 46.92648714475283], [36.25, 47.0], [36.253611454995855, 47.07351285524717], [36.26441103969758, 47.1463177415121], [36.28229474820084, 47.21771350794085], [36.307090350616534, 47.28701257427382], [36.338559051738734, 47.353547552619496], [36.37639779077309, 47.4166776747647], [36.420242159977946, 47.47579496312273], [36.46966991411009, 47.53033008588991], [36.52420503687726, 47.579757840022054], [36.5833223252353, 47.62360220922691], [36.646452447380504, 47.661440948261266], [36.71298742572618, 47.692909649383466], [36.78228649205915, 47.71770525179916], [36.8536822584879, 47.73558896030242], [36.92648714475283, 47.746388545004145], [37.0, 47.75], [37.07351285524717, 47.746388545004145], [37.1463177415121, 47.73558896030242], [37.21771350794084, 47.71770525179916], [37.28701257427382, 47.692909649383466], [37.353547552619496, 47.661440948261266], [37.4166776747647, 47.62360220922691], [37.47579496312274, 47.579757840022054], [37.53033008588991, 47.53033008588991], [37.579757840022054, 47.47579496312274], [37.62360220922691, 47.4166776747647], [37.661440948261266, 47.353547552619496], [37.692909649383466, 47.28701257427382], [37.71770525179916, 47.21771350794085], [37.73558896030242, 47.1463177415121], [37.746388545004145, 47.07351285524717], [37.75, 47.0], [37.746388545004145, 46.92648714475283], [37.73558896030242, 46.8536822584879], [37.71770525179916, 46.78228649205915], [37.692909649383466, 46.71298742572618], [37.661440948261266, 46.646452447380504], [37.62360220922691, 46.5833223252353], [37.579757840022054, 46.52420503687726], [37.53033008588991, 46.46966991411009], [37.47579496312274, 46.420242159977946], [37.4166776747647, 46.37639779077309], [37.353547552619496, 46.338559051738734]]], [[[27.916677674764703, 46.87639779077309], [27.8535475526195, 46.838559051738734], [27.787012574273817, 46.807090350616534], [27.717713507940847, 46.78229474820084], [27.646317741512096, 46.76441103969758], [27.57351285524717, 46.753611454995855], [27.5, 46.75], [27.42648714475283, 46.753611454995855], [27.353682258487904, 46.76441103969758], [27.282286492059153, 46.78229474820084], [27.212987425726183, 46.807090350616534], [27.1464524473805, 46.838559051738734], [27.083322325235297, 46.87639779077309], [27.024205036877266, 46.920242159977946], [26.96966991411009, 46.96966991411009], [26.920242159977946, 47.02420503687726], [26.87639779077309, 47.0833223252353], [26.838559051738734, 47.146452447380504], [26.807090350616534, 47.21298742572618], [26.782294748200844, 47.28228649205915], [26.764411039697578, 47.3536822584879], [26.753611454995852, 47.42648714475283], [26.75, 47.5], [26.753611454995852, 47.57351285524717], [26.764411039697578, 47.6463177415121], [26.782294748200844, 47.71771350794085], [26.807090350616534, 47.78701257427382], [26.838559051738734, 47.853547552619496], [26.87639779077309, 47.9166776747647], [26.920242159977946, 47.97579496312273], [26.96966991411009, 48.03033008588991], [27.024205036877266, 48.079757840022054], [27.083322325235297, 48.12360220922691], [27.1464524473805, 48.161440948261266], [27.212987425726183, 48.192909649383466], [27.282286492059153, 48.21770525179916], [27.353682258487904, 48.23558896030242], [27.42648714475283, 48.246388545004145], [27.5, 48.25], [27.57351285524717, 48.246388545004145], [27.646317741512096, 48.23558896030242], [27.717713507940847, 48.21770525179916], [27.787012574273817, 48.192909649383466], [27.8535475526195, 48.161440948261266], [27.916677674764703, 48.12360220922691], [27.975794963122734, 48.079757840022054], [28.03033008588991, 48.03033008588991], [28.07975784002205, 47.97579496312274], [28.12360220922691, 47.9166776747647], [28.161440948261266, 47.853547552619496], [28.192909649383466, 47.78701257427382], [28.217705251799156, 47.71771350794085], [28.235588960302422, 47.6463177415121], [28.246388545004148, 47.57351285524717], [28.25, 47.5], [28.246388545004148, 47.42648714475283], [28.235588960302422, 47.3536822584879], [28.217705251799156, 47.28228649205915], [28.192909649383466, 47.21298742572618], [28.161440948261266, 47.146452447380504], [28.12360220922691, 47.0833223252353], [28.079757840022054, 47.02420503687726], [28.03033008588991, 46.96966991411009], [27.975794963122734, 46.920242159977946], [27.916677674764703, 46.87639779077309]]], [[[23.3535475526195, 47.338559051738734], [23.287012574273817, 47.307090350616534], [23.217713507940847, 47.28229474820084], [23.146317741512096, 47.26441103969758], [23.07351285524717, 47.253611454995855], [23.0, 47.25], [22.92648714475283, 47.253611454995855], [22.853682258487904, 47.26441103969758], [22.782286492059153, 47.28229474820084], [22.712987425726183, 47.307090350616534], [22.6464524473805, 47.338559051738734], [22.583322325235297, 47.37639779077309], [22.524205036877266, 47.420242159977946], [22.46966991411009, 47.46966991411009], [22.420242159977946, 47.52420503687726], [22.37639779077309, 47.5833223252353], [22.338559051738734, 47.646452447380504], [22.307090350616534, 47.71298742572618], [22.282294748200844, 47.78228649205915], [22.264411039697578, 47.8536822584879], [22.253611454995852, 47.92648714475283], [22.25, 48.0], [22.253611454995852, 48.07351285524717], [22.264411039697578, 48.1463177415121], [22.282294748200844, 48.21771350794085], [22.307090350616534, 48.28701257427382], [22.338559051738734, 48.353547552619496], [22.37639779077309, 48.4166776747647], [22.420242159977946, 48.47579496312273], [22.46966991411009, 48.53033008588991], [22.524205036877266, 48.579757840022054], [22.583322325235297, 48.62360220922691], [22.6464524473805, 48.661440948261266], [22.712987425726183, 48.692909649383466], [22.782286492059153, 48.71770525179916], [22.853682258487904, 48.73558896030242], [22.92648714475283, 48.746388545004145], [23.0, 48.75], [23.07351285524717, 48.746388545004145], [23.146317741512096, 48.73558896030242], [23.217713507940847, 48.71770525179916], [23.287012574273817, 48.692909649383466], [23.3535475526195, 48.661440948261266], [23.416677674764703, 48.62360220922691], [23.475794963122734, 48.579757840022054], [23.53033008588991, 48.53033008588991], [23.57975784002205, 48.47579496312274], [23.62360220922691, 48.4166776747647], [23.661440948261266, 48.353547552619496], [23.692909649383466, 48.28701257427382], [23.717705251799156, 48.21771350794085], [23.735588960302422, 48.1463177415121], [23.746388545004148, 48.07351285524717], [23.75, 48.0], [23.746388545004148, 47.92648714475283], [23.735588960302422, 47.8536822584879], [23.717705251799156, 47.78228649205915], [23.692909649383466, 47.71298742572618], [23.661440948261266, 47.646452447380504], [23.62360220922691, 47.5833223252353], [23.579757840022054, 47.52420503687726], [23.53033008588991, 47.46966991411009], [23.475794963122734, 47.420242159977946], [23.416677674764703, 47.37639779077309], [23.3535475526195, 47.338559051738734]]], [[[31.8535475526195, 47.338559051738734], [31.787012574273817, 47.307090350616534], [31.717713507940847, 47.28229474820084], [31.646317741512096, 47.26441103969758], [31.57351285524717, 47.253611454995855], [31.5, 47.25], [31.42648714475283, 47.253611454995855], [31.353682258487904, 47.26441103969758], [31.282286492059153, 47.28229474820084], [31.212987425726183, 47.307090350616534], [31.1464524473805, 47.338559051738734], [31.083322325235297, 47.37639779077309], [31.024205036877266, 47.420242159977946], [30.96966991411009, 47.46966991411009], [30.920242159977946, 47.52420503687726], [30.87639779077309, 47.5833223252353], [30.838559051738734, 47.646452447380504], [30.807090350616534, 47.71298742572618], [30.782294748200844, 47.78228649205915], [30.764411039697578, 47.8536822584879], [30.753611454995852, 47.92648714475283], [30.75, 48.0], [30.753611454995852, 48.07351285524717], [30.764411039697578, 48.1463177415121], [30.782294748200844, 48.21771350794085], [30.807090350616534, 48.28701257427382], [30.838559051738734, 48.353547552619496], [30.87639779077309, 48.4166776747647], [30.920242159977946, 48.47579496312273], [30.96966991411009, 48.53033008588991], [31.024205036877266, 48.579757840022054], [31.083322325235297, 48.62360220922691], [31.1464524473805, 48.661440948261266], [31.212987425726183, 48.692909649383466], [31.282286492059153, 48.71770525179916], [31.353682258487904, 48.73558896030242], [31.42648714475283, 48.746388545004145], [31.5, 48.75], [31.57351285524717, 48.746388545004145], [31.646317741512096, 48.73558896030242], [31.717713507940847, 48.71770525179916], [31.787012574273817, 48.692909649383466], [31.8535475526195, 48.661440948261266], [31.916677674764703, 48.62360220922691], [31.975794963122734, 48.579757840022054], [32.03033008588991, 48.53033008588991], [32.079757840022054, 48.47579496312274], [32.12360220922691, 48.4166776747647], [32.161440948261266, 48.353547552619496], [32.192909649383466, 48.28701257427382], [32.21770525179916, 48.21771350794085], [32.23558896030242, 48.1463177415121], [32.246388545004145, 48.07351285524717], [32.25, 48.0], [32.246388545004145, 47.92648714475283], [32.23558896030242, 47.8536822584879], [32.21770525179916, 47.78228649205915], [32.192909649383466, 47.71298742572618], [32.161440948261266, 47.646452447380504], [32.12360220922691, 47.5833223252353], [32.079757840022054, 47.52420503687726], [32.03033008588991, 47.46966991411009], [31.975794963122734, 47.420242159977946], [31.916677674764703, 47.37639779077309], [31.8535475526195, 47.338559051738734]]]]} | 0.968162 | 10.5859 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 |  | SURFACE_GROUP | PK.50.60.B | PK.50.20.B;PK.50.60.B;PK.70.10.B | B_check;B_mulch;B_soil | 3 | 수목 하부 멀칭 | 20 수목·녹지 | 신규 교목 하부 멀칭 면적
green_C | 일반녹지 / green_C | VEGETATION | PK.50.60.C 수목 하부 멀칭 / C구역 (수목 하부 멀칭) | green_C | green | C | {"type": "MultiPolygon", "coordinates": [[[[7.475794963122734, 4.420242159977947], [7.416677674764702, 4.376397790773091], [7.353547552619498, 4.338559051738734], [7.287012574273818, 4.3070903506165354], [7.2177135079408465, 4.282294748200844], [7.146317741512096, 4.264411039697578], [7.073512855247171, 4.253611454995852], [7.0, 4.25], [6.926487144752829, 4.253611454995852], [6.853682258487904, 4.264411039697578], [6.7822864920591535, 4.282294748200844], [6.712987425726182, 4.3070903506165354], [6.646452447380502, 4.338559051738733], [6.583322325235298, 4.376397790773091], [6.524205036877266, 4.420242159977947], [6.4696699141100895, 4.4696699141100895], [6.420242159977947, 4.524205036877266], [6.376397790773091, 4.583322325235298], [6.338559051738734, 4.646452447380502], [6.3070903506165354, 4.712987425726182], [6.282294748200844, 4.7822864920591535], [6.264411039697578, 4.853682258487903], [6.253611454995852, 4.926487144752829], [6.25, 5.0], [6.253611454995852, 5.07351285524717], [6.264411039697578, 5.146317741512096], [6.282294748200844, 5.2177135079408465], [6.307090350616535, 5.287012574273818], [6.338559051738733, 5.353547552619498], [6.37639779077309, 5.416677674764702], [6.420242159977947, 5.475794963122734], [6.4696699141100895, 5.5303300858899105], [6.524205036877266, 5.579757840022053], [6.583322325235298, 5.623602209226909], [6.646452447380502, 5.661440948261266], [6.712987425726182, 5.6929096493834646], [6.7822864920591535, 5.717705251799156], [6.853682258487903, 5.735588960302422], [6.92648714475283, 5.746388545004148], [7.0, 5.75], [7.07351285524717, 5.746388545004148], [7.146317741512096, 5.735588960302422], [7.2177135079408465, 5.717705251799156], [7.287012574273818, 5.6929096493834646], [7.353547552619498, 5.661440948261267], [7.416677674764701, 5.62360220922691], [7.475794963122734, 5.579757840022053], [7.5303300858899105, 5.5303300858899105], [7.579757840022053, 5.475794963122734], [7.623602209226909, 5.416677674764702], [7.661440948261266, 5.353547552619498], [7.6929096493834646, 5.287012574273818], [7.717705251799156, 5.2177135079408465], [7.735588960302422, 5.146317741512097], [7.746388545004148, 5.07351285524717], [7.75, 5.0], [7.746388545004148, 4.926487144752829], [7.735588960302422, 4.853682258487904], [7.717705251799156, 4.7822864920591535], [7.6929096493834646, 4.712987425726182], [7.661440948261267, 4.646452447380502], [7.623602209226909, 4.583322325235298], [7.579757840022053, 4.524205036877266], [7.5303300858899105, 4.4696699141100895], [7.475794963122734, 4.420242159977947]]], [[[5.475794963122734, 11.420242159977947], [5.416677674764702, 11.37639779077309], [5.353547552619498, 11.338559051738734], [5.287012574273818, 11.307090350616535], [5.2177135079408465, 11.282294748200844], [5.146317741512096, 11.264411039697578], [5.073512855247171, 11.253611454995852], [5.0, 11.25], [4.926487144752829, 11.253611454995852], [4.853682258487904, 11.264411039697578], [4.7822864920591535, 11.282294748200844], [4.712987425726182, 11.307090350616535], [4.646452447380502, 11.338559051738734], [4.583322325235298, 11.37639779077309], [4.524205036877266, 11.420242159977947], [4.4696699141100895, 11.469669914110089], [4.420242159977947, 11.524205036877266], [4.376397790773091, 11.583322325235299], [4.338559051738734, 11.646452447380502], [4.3070903506165354, 11.712987425726183], [4.282294748200844, 11.782286492059153], [4.264411039697578, 11.853682258487904], [4.253611454995852, 11.92648714475283], [4.25, 12.0], [4.253611454995852, 12.07351285524717], [4.264411039697578, 12.146317741512096], [4.282294748200844, 12.217713507940847], [4.307090350616535, 12.287012574273817], [4.338559051738733, 12.353547552619498], [4.37639779077309, 12.416677674764701], [4.420242159977947, 12.475794963122734], [4.4696699141100895, 12.530330085889911], [4.524205036877266, 12.579757840022053], [4.583322325235298, 12.62360220922691], [4.646452447380502, 12.661440948261266], [4.712987425726182, 12.692909649383465], [4.7822864920591535, 12.717705251799156], [4.853682258487903, 12.735588960302422], [4.92648714475283, 12.746388545004148], [5.0, 12.75], [5.07351285524717, 12.746388545004148], [5.146317741512096, 12.735588960302422], [5.2177135079408465, 12.717705251799156], [5.287012574273818, 12.692909649383465], [5.353547552619498, 12.661440948261266], [5.416677674764701, 12.62360220922691], [5.475794963122734, 12.579757840022053], [5.5303300858899105, 12.530330085889911], [5.579757840022053, 12.475794963122734], [5.623602209226909, 12.416677674764701], [5.661440948261266, 12.3535475526195], [5.6929096493834646, 12.287012574273819], [5.717705251799156, 12.217713507940847], [5.735588960302422, 12.146317741512096], [5.746388545004148, 12.07351285524717], [5.75, 12.0], [5.746388545004148, 11.92648714475283], [5.735588960302422, 11.853682258487904], [5.717705251799156, 11.782286492059153], [5.6929096493834646, 11.712987425726183], [5.661440948261267, 11.646452447380502], [5.623602209226909, 11.583322325235299], [5.579757840022053, 11.524205036877266], [5.5303300858899105, 11.469669914110089], [5.475794963122734, 11.420242159977947]]]]} | 0.585662 | 3.52862 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 |  | SURFACE_GROUP | PK.50.60.C | PK.50.20.C;PK.50.60.C;PK.70.10.C | C_check;C_mulch;C_soil | 3 | 수목 하부 멀칭 | 20 수목·녹지 | 신규 교목 하부 멀칭 면적
green_D | 일반녹지 / green_D | VEGETATION | PK.50.60.D 수목 하부 멀칭 / D구역 (수목 하부 멀칭) | green_D | green | D | {"type": "MultiPolygon", "coordinates": [[[[35.4166776747647, 3.8763977907730913], [35.353547552619496, 3.838559051738734], [35.28701257427382, 3.807090350616535], [35.21771350794085, 3.7822947482008433], [35.1463177415121, 3.764411039697577], [35.07351285524717, 3.7536114549958524], [35.0, 3.75], [34.92648714475283, 3.7536114549958524], [34.8536822584879, 3.764411039697577], [34.78228649205915, 3.7822947482008433], [34.71298742572618, 3.807090350616535], [34.646452447380504, 3.838559051738734], [34.5833223252353, 3.876397790773091], [34.52420503687726, 3.9202421599779473], [34.46966991411009, 3.9696699141100895], [34.420242159977946, 4.024205036877266], [34.37639779077309, 4.083322325235298], [34.338559051738734, 4.146452447380502], [34.307090350616534, 4.212987425726182], [34.28229474820084, 4.2822864920591535], [34.26441103969758, 4.353682258487903], [34.253611454995855, 4.426487144752829], [34.25, 4.5], [34.253611454995855, 4.57351285524717], [34.26441103969758, 4.646317741512096], [34.28229474820084, 4.7177135079408465], [34.307090350616534, 4.787012574273818], [34.338559051738734, 4.853547552619498], [34.37639779077309, 4.916677674764702], [34.420242159977946, 4.975794963122734], [34.46966991411009, 5.0303300858899105], [34.52420503687726, 5.079757840022053], [34.5833223252353, 5.123602209226909], [34.646452447380504, 5.161440948261266], [34.71298742572618, 5.1929096493834646], [34.78228649205915, 5.217705251799156], [34.8536822584879, 5.235588960302422], [34.92648714475283, 5.246388545004148], [35.0, 5.25], [35.07351285524717, 5.246388545004148], [35.1463177415121, 5.235588960302422], [35.21771350794084, 5.217705251799156], [35.28701257427382, 5.1929096493834646], [35.353547552619496, 5.161440948261267], [35.4166776747647, 5.12360220922691], [35.47579496312274, 5.079757840022053], [35.53033008588991, 5.0303300858899105], [35.579757840022054, 4.975794963122734], [35.62360220922691, 4.916677674764702], [35.661440948261266, 4.853547552619498], [35.692909649383466, 4.787012574273818], [35.71770525179916, 4.7177135079408465], [35.73558896030242, 4.646317741512097], [35.746388545004145, 4.57351285524717], [35.75, 4.5], [35.746388545004145, 4.426487144752829], [35.73558896030242, 4.353682258487904], [35.71770525179916, 4.2822864920591535], [35.692909649383466, 4.212987425726182], [35.661440948261266, 4.146452447380502], [35.62360220922691, 4.083322325235298], [35.579757840022054, 4.024205036877266], [35.53033008588991, 3.9696699141100895], [35.47579496312274, 3.9202421599779473], [35.4166776747647, 3.8763977907730913]]], [[[25.416677674764703, 4.376397790773091], [25.3535475526195, 4.338559051738734], [25.287012574273817, 4.3070903506165354], [25.217713507940847, 4.282294748200844], [25.146317741512096, 4.264411039697578], [25.07351285524717, 4.253611454995852], [25.0, 4.25], [24.92648714475283, 4.253611454995852], [24.853682258487904, 4.264411039697578], [24.782286492059153, 4.282294748200844], [24.712987425726183, 4.3070903506165354], [24.6464524473805, 4.338559051738733], [24.583322325235297, 4.376397790773091], [24.524205036877266, 4.420242159977947], [24.46966991411009, 4.4696699141100895], [24.420242159977946, 4.524205036877266], [24.37639779077309, 4.583322325235298], [24.338559051738734, 4.646452447380502], [24.307090350616534, 4.712987425726182], [24.282294748200844, 4.7822864920591535], [24.264411039697578, 4.853682258487903], [24.253611454995852, 4.926487144752829], [24.25, 5.0], [24.253611454995852, 5.07351285524717], [24.264411039697578, 5.146317741512096], [24.282294748200844, 5.2177135079408465], [24.307090350616534, 5.287012574273818], [24.338559051738734, 5.353547552619498], [24.37639779077309, 5.416677674764702], [24.420242159977946, 5.475794963122734], [24.46966991411009, 5.5303300858899105], [24.524205036877266, 5.579757840022053], [24.583322325235297, 5.623602209226909], [24.6464524473805, 5.661440948261266], [24.712987425726183, 5.6929096493834646], [24.782286492059153, 5.717705251799156], [24.853682258487904, 5.735588960302422], [24.92648714475283, 5.746388545004148], [25.0, 5.75], [25.07351285524717, 5.746388545004148], [25.146317741512096, 5.735588960302422], [25.217713507940847, 5.717705251799156], [25.287012574273817, 5.6929096493834646], [25.3535475526195, 5.661440948261267], [25.416677674764703, 5.62360220922691], [25.475794963122734, 5.579757840022053], [25.53033008588991, 5.5303300858899105], [25.57975784002205, 5.475794963122734], [25.62360220922691, 5.416677674764702], [25.661440948261266, 5.353547552619498], [25.692909649383466, 5.287012574273818], [25.717705251799156, 5.2177135079408465], [25.735588960302422, 5.146317741512097], [25.746388545004148, 5.07351285524717], [25.75, 5.0], [25.746388545004148, 4.926487144752829], [25.735588960302422, 4.853682258487904], [25.717705251799156, 4.7822864920591535], [25.692909649383466, 4.712987425726182], [25.661440948261266, 4.646452447380502], [25.62360220922691, 4.583322325235298], [25.579757840022054, 4.524205036877266], [25.53033008588991, 4.4696699141100895], [25.475794963122734, 4.420242159977947], [25.416677674764703, 4.376397790773091]]], [[[37.4166776747647, 8.37639779077309], [37.353547552619496, 8.338559051738734], [37.28701257427382, 8.307090350616535], [37.21771350794085, 8.282294748200844], [37.1463177415121, 8.264411039697578], [37.07351285524717, 8.253611454995852], [37.0, 8.25], [36.92648714475283, 8.253611454995852], [36.8536822584879, 8.264411039697578], [36.78228649205915, 8.282294748200844], [36.71298742572618, 8.307090350616535], [36.646452447380504, 8.338559051738734], [36.5833223252353, 8.37639779077309], [36.52420503687726, 8.420242159977947], [36.46966991411009, 8.469669914110089], [36.420242159977946, 8.524205036877266], [36.37639779077309, 8.583322325235299], [36.338559051738734, 8.646452447380502], [36.307090350616534, 8.712987425726183], [36.28229474820084, 8.782286492059153], [36.26441103969758, 8.853682258487904], [36.253611454995855, 8.92648714475283], [36.25, 9.0], [36.253611454995855, 9.07351285524717], [36.26441103969758, 9.146317741512096], [36.28229474820084, 9.217713507940847], [36.307090350616534, 9.287012574273817], [36.338559051738734, 9.353547552619498], [36.37639779077309, 9.416677674764701], [36.420242159977946, 9.475794963122734], [36.46966991411009, 9.530330085889911], [36.52420503687726, 9.579757840022053], [36.5833223252353, 9.62360220922691], [36.646452447380504, 9.661440948261266], [36.71298742572618, 9.692909649383465], [36.78228649205915, 9.717705251799156], [36.8536822584879, 9.735588960302422], [36.92648714475283, 9.746388545004148], [37.0, 9.75], [37.07351285524717, 9.746388545004148], [37.1463177415121, 9.735588960302422], [37.21771350794084, 9.717705251799156], [37.28701257427382, 9.692909649383465], [37.353547552619496, 9.661440948261266], [37.4166776747647, 9.62360220922691], [37.47579496312274, 9.579757840022053], [37.53033008588991, 9.530330085889911], [37.579757840022054, 9.475794963122734], [37.62360220922691, 9.416677674764701], [37.661440948261266, 9.3535475526195], [37.692909649383466, 9.287012574273819], [37.71770525179916, 9.217713507940847], [37.73558896030242, 9.146317741512096], [37.746388545004145, 9.07351285524717], [37.75, 9.0], [37.746388545004145, 8.92648714475283], [37.73558896030242, 8.853682258487904], [37.71770525179916, 8.782286492059153], [37.692909649383466, 8.712987425726183], [37.661440948261266, 8.646452447380502], [37.62360220922691, 8.583322325235299], [37.579757840022054, 8.524205036877266], [37.53033008588991, 8.469669914110089], [37.47579496312274, 8.420242159977947], [37.4166776747647, 8.37639779077309]]], [[[36.9166776747647, 22.87639779077309], [36.853547552619496, 22.838559051738734], [36.78701257427382, 22.807090350616534], [36.71771350794085, 22.782294748200844], [36.6463177415121, 22.764411039697578], [36.57351285524717, 22.753611454995852], [36.5, 22.75], [36.42648714475283, 22.753611454995852], [36.3536822584879, 22.764411039697578], [36.28228649205915, 22.782294748200844], [36.21298742572618, 22.807090350616534], [36.146452447380504, 22.838559051738734], [36.0833223252353, 22.87639779077309], [36.02420503687726, 22.920242159977946], [35.96966991411009, 22.96966991411009], [35.920242159977946, 23.024205036877266], [35.87639779077309, 23.083322325235297], [35.838559051738734, 23.1464524473805], [35.807090350616534, 23.212987425726183], [35.78229474820084, 23.282286492059153], [35.76441103969758, 23.353682258487904], [35.753611454995855, 23.42648714475283], [35.75, 23.5], [35.753611454995855, 23.57351285524717], [35.76441103969758, 23.646317741512096], [35.78229474820084, 23.717713507940847], [35.807090350616534, 23.787012574273817], [35.838559051738734, 23.8535475526195], [35.87639779077309, 23.916677674764703], [35.920242159977946, 23.975794963122734], [35.96966991411009, 24.03033008588991], [36.02420503687726, 24.07975784002205], [36.0833223252353, 24.12360220922691], [36.146452447380504, 24.161440948261266], [36.21298742572618, 24.192909649383466], [36.28228649205915, 24.217705251799156], [36.3536822584879, 24.235588960302422], [36.42648714475283, 24.246388545004148], [36.5, 24.25], [36.57351285524717, 24.246388545004148], [36.6463177415121, 24.235588960302422], [36.71771350794084, 24.217705251799156], [36.78701257427382, 24.192909649383466], [36.853547552619496, 24.161440948261266], [36.9166776747647, 24.12360220922691], [36.97579496312274, 24.079757840022054], [37.03033008588991, 24.03033008588991], [37.079757840022054, 23.975794963122734], [37.12360220922691, 23.916677674764703], [37.161440948261266, 23.8535475526195], [37.192909649383466, 23.787012574273817], [37.21770525179916, 23.717713507940847], [37.23558896030242, 23.646317741512096], [37.246388545004145, 23.57351285524717], [37.25, 23.5], [37.246388545004145, 23.42648714475283], [37.23558896030242, 23.353682258487904], [37.21770525179916, 23.282286492059153], [37.192909649383466, 23.212987425726183], [37.161440948261266, 23.1464524473805], [37.12360220922691, 23.083322325235297], [37.079757840022054, 23.024205036877266], [37.03033008588991, 22.96966991411009], [36.97579496312274, 22.920242159977946], [36.9166776747647, 22.87639779077309]]]]} | 0.156662 | 7.05723 | z=0.015*(40-x)+0.018*y | 0.005 | 0.04 |  | SURFACE_GROUP | PK.50.60.D | PK.50.20.D;PK.50.60.D;PK.70.10.D | D_check;D_mulch;D_soil | 3 | 수목 하부 멀칭 | 20 수목·녹지 | 신규 교목 하부 멀칭 면적
TERRAIN | 합성 지형 기준면 / TERRAIN | TERRAIN | PK.70.30.SITE 준공검사 / 전체 (준공검사) | TERRAIN | terrain | SITE | {"type": "Polygon", "coordinates": [[[40.0, 0.0], [40.0, 50.0], [0.0, 50.0], [0.0, 0.0], [40.0, 0.0]]]} | 0.75 |  |  |  |  |  | REFERENCE | PK.70.30.SITE | PK.10.10.SITE;PK.10.20.SITE;PK.20.05.SITE;PK.20.30.SITE;PK.20.40.SITE;PK.70.20.SITE;PK.70.30.SITE | HANDOVER;RESTORE;SITE_drainage;SITE_draincheck;SITE_grade;SITE_strip;SITE_survey | 7 | 합성 지형 기준면 | 10 포장·경계·지형 | Reference and work-scope objects are excluded from installed-item totals

# IfcGeographicElement: 느티나무 H4.0 X R12 (3)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 느티나무; NurserySpecification: H4.0 X R12; CrownWidthBasis: DISPLAY_ASSUMPTION
LCS_Provenance - Kind: new_tree; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; PlantingRevision: P2; Height_m: 4; CrownWidth_m: 3; RootCollarDiameter_cm: 12; StemVisualizationDiameter_m: 0.12; StemDiameterBasis: Catalog R represented by a simple cylinder; CrownBaseDisplay_m: 1.7; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; TreeGeometry: Planting-stock envelope; species-specific source IFC geometry not copied
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 느티나무; NurseryOrFacilitySpecification: H4.0 X R12; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_N01 | 느티나무 / H4.0 X R12 / P2_N01 | PK.50.30.C 교목 식재(구덩이 포함) / C구역 (교목 식재(구덩이 포함)) | P2_N01 | C | {"type": "Point", "coordinates": [7.0, 5.0]} | 0.585 | PK.50.30.C | PK.50.30.C;PK.70.10.C | C_check;C_trees
P2_N02 | 느티나무 / H4.0 X R12 / P2_N02 | PK.50.30.A 교목 식재(구덩이 포함) / A구역 (교목 식재(구덩이 포함)) | P2_N02 | A | {"type": "Point", "coordinates": [11.0, 43.8]} | 1.2234 | PK.50.30.A | PK.50.30.A;PK.70.10.A | A_check;A_trees
P2_N03 | 느티나무 / H4.0 X R12 / P2_N03 | PK.50.30.B 교목 식재(구덩이 포함) / B구역 (교목 식재(구덩이 포함)) | P2_N03 | B | {"type": "Point", "coordinates": [27.0, 31.0]} | 0.753 | PK.50.30.B | PK.50.30.B;PK.70.10.B | B_check;B_trees

# IfcGeographicElement: 산딸나무 H3.0 X R8 (3)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 산딸나무; NurserySpecification: H3.0 X R8; CrownWidthBasis: DISPLAY_ASSUMPTION
LCS_Provenance - Kind: new_tree; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; PlantingRevision: P2; Height_m: 3; CrownWidth_m: 2; RootCollarDiameter_cm: 8; StemVisualizationDiameter_m: 0.08; StemDiameterBasis: Catalog R represented by a simple cylinder; CrownBaseDisplay_m: 1.1; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; TreeGeometry: Planting-stock envelope; species-specific source IFC geometry not copied
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 산딸나무; NurseryOrFacilitySpecification: H3.0 X R8; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_D01 | 산딸나무 / H3.0 X R8 / P2_D01 | PK.50.30.B 교목 식재(구덩이 포함) / B구역 (교목 식재(구덩이 포함)) | P2_D01 | B | {"type": "Point", "coordinates": [37.0, 47.0]} | 0.891 | PK.50.30.B | PK.50.30.B;PK.70.10.B | B_check;B_trees
P2_D02 | 산딸나무 / H3.0 X R8 / P2_D02 | PK.50.30.A 교목 식재(구덩이 포함) / A구역 (교목 식재(구덩이 포함)) | P2_D02 | A | {"type": "Point", "coordinates": [3.0, 37.0]} | 1.221 | PK.50.30.A | PK.50.30.A;PK.70.10.A | A_check;A_trees
P2_D03 | 산딸나무 / H3.0 X R8 / P2_D03 | PK.50.30.D 교목 식재(구덩이 포함) / D구역 (교목 식재(구덩이 포함)) | P2_D03 | D | {"type": "Point", "coordinates": [37.0, 9.0]} | 0.207 | PK.50.30.D | PK.50.30.D;PK.70.10.D | D_check;D_trees

# IfcGeographicElement: 산철쭉 H0.8 X W0.8 (160)
In: Local synthetic site; not georeferenced
Type - PredefinedType: VEGETATION
Type - LCS_ModelDetail - Species: 산철쭉; NurserySpecification: H0.8 X W0.8
LCS_Provenance - Kind: shrub_plant; Source: SYNTHETIC
LCS_Quantities - install: 1
LCS_ModelDetail - DetailStatus: CONCEPT_ASSUMED_NOT_FOR_CONSTRUCTION; DesignVersion: 0.4.0-R1; SourceBaselineHash: 10bf425da4804b2c4726592601264ecdb44df0d1a92b527da73d39a5d13392c4; QuantitiesBasis: Unchanged QGIS design ledger; plan area and projected pipe length; GeometryRole: PHYSICAL_CONCEPT; Height_m: 0.8; CrownWidth_m: 0.8; CenterSpacing_m: 0.85; CatalogSHA256: ae704ba62d4259bc10289ba162f313e69d0bef03fb744bfe145340ed6f990d19; Quantity: 1; GeometryBasis: Nursery H/W envelope; not mature crown
LCS_WBS - InventoryRole: NEW; LinkedTaskCount: 2; ItemName: 산철쭉; NurseryOrFacilitySpecification: H0.8 X W0.8; ClassificationVersion: R1-WBS2
Group: 20 수목·녹지
Name | Description | Classification | LCS_Provenance, ObjectId = LCS_WBS, ObjectId | Zone | GeometryJSON | ElevationMetre | MassId | PrimaryWBS | WBSCodeList | LegacyTaskIds
P2_R01-001 | 관목 개체 / P2_R01-001 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-001 | C | {"type": "Point", "coordinates": [2.1153125, 13.653621593216773]} | 0.814036 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-002 | 관목 개체 / P2_R01-002 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-002 | C | {"type": "Point", "coordinates": [2.9653125, 13.653621593216773]} | 0.801286 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-003 | 관목 개체 / P2_R01-003 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-003 | C | {"type": "Point", "coordinates": [1.6903124999999999, 14.389743186433545]} | 0.833661 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-004 | 관목 개체 / P2_R01-004 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-004 | C | {"type": "Point", "coordinates": [2.5403124999999998, 14.389743186433545]} | 0.820911 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-005 | 관목 개체 / P2_R01-005 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-005 | C | {"type": "Point", "coordinates": [3.3903125, 14.389743186433545]} | 0.808161 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-006 | 관목 개체 / P2_R01-006 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-006 | C | {"type": "Point", "coordinates": [1.2653124999999998, 15.12586477965032]} | 0.853286 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-007 | 관목 개체 / P2_R01-007 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-007 | C | {"type": "Point", "coordinates": [2.1153125, 15.12586477965032]} | 0.840536 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-008 | 관목 개체 / P2_R01-008 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-008 | C | {"type": "Point", "coordinates": [2.9653125, 15.12586477965032]} | 0.827786 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-009 | 관목 개체 / P2_R01-009 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-009 | C | {"type": "Point", "coordinates": [1.6903124999999999, 15.861986372867092]} | 0.860161 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-010 | 관목 개체 / P2_R01-010 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-010 | C | {"type": "Point", "coordinates": [2.5403124999999998, 15.861986372867092]} | 0.847411 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-011 | 관목 개체 / P2_R01-011 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-011 | C | {"type": "Point", "coordinates": [3.3903125, 15.861986372867092]} | 0.834661 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-012 | 관목 개체 / P2_R01-012 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-012 | C | {"type": "Point", "coordinates": [1.2653124999999998, 16.598107966083866]} | 0.879786 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-013 | 관목 개체 / P2_R01-013 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-013 | C | {"type": "Point", "coordinates": [2.1153125, 16.598107966083866]} | 0.867036 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-014 | 관목 개체 / P2_R01-014 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-014 | C | {"type": "Point", "coordinates": [2.9653125, 16.598107966083866]} | 0.854286 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-015 | 관목 개체 / P2_R01-015 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-015 | C | {"type": "Point", "coordinates": [3.8153125, 16.598107966083866]} | 0.841536 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-016 | 관목 개체 / P2_R01-016 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-016 | C | {"type": "Point", "coordinates": [1.6903124999999999, 17.33422955930064]} | 0.886661 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-017 | 관목 개체 / P2_R01-017 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-017 | C | {"type": "Point", "coordinates": [2.5403124999999998, 17.33422955930064]} | 0.873911 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-018 | 관목 개체 / P2_R01-018 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-018 | C | {"type": "Point", "coordinates": [3.3903125, 17.33422955930064]} | 0.861161 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-019 | 관목 개체 / P2_R01-019 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-019 | C | {"type": "Point", "coordinates": [4.2403125, 17.33422955930064]} | 0.848411 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-020 | 관목 개체 / P2_R01-020 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-020 | C | {"type": "Point", "coordinates": [1.2653124999999998, 18.07035115251741]} | 0.906287 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-021 | 관목 개체 / P2_R01-021 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-021 | C | {"type": "Point", "coordinates": [2.1153125, 18.07035115251741]} | 0.893537 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-022 | 관목 개체 / P2_R01-022 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-022 | C | {"type": "Point", "coordinates": [2.9653125, 18.07035115251741]} | 0.880787 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-023 | 관목 개체 / P2_R01-023 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-023 | C | {"type": "Point", "coordinates": [3.8153125, 18.07035115251741]} | 0.868037 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-024 | 관목 개체 / P2_R01-024 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-024 | C | {"type": "Point", "coordinates": [1.6903124999999999, 18.806472745734183]} | 0.913162 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-025 | 관목 개체 / P2_R01-025 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-025 | C | {"type": "Point", "coordinates": [2.5403124999999998, 18.806472745734183]} | 0.900412 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-026 | 관목 개체 / P2_R01-026 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-026 | C | {"type": "Point", "coordinates": [3.3903125, 18.806472745734183]} | 0.887662 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-027 | 관목 개체 / P2_R01-027 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-027 | C | {"type": "Point", "coordinates": [4.2403125, 18.806472745734183]} | 0.874912 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-028 | 관목 개체 / P2_R01-028 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-028 | C | {"type": "Point", "coordinates": [1.2653124999999998, 19.542594338950956]} | 0.932787 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-029 | 관목 개체 / P2_R01-029 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-029 | C | {"type": "Point", "coordinates": [2.1153125, 19.542594338950956]} | 0.920037 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-030 | 관목 개체 / P2_R01-030 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-030 | C | {"type": "Point", "coordinates": [2.9653125, 19.542594338950956]} | 0.907287 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-031 | 관목 개체 / P2_R01-031 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-031 | C | {"type": "Point", "coordinates": [3.8153125, 19.542594338950956]} | 0.894537 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-032 | 관목 개체 / P2_R01-032 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-032 | C | {"type": "Point", "coordinates": [1.6903124999999999, 20.278715932167728]} | 0.939662 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-033 | 관목 개체 / P2_R01-033 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-033 | C | {"type": "Point", "coordinates": [2.5403124999999998, 20.278715932167728]} | 0.926912 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-034 | 관목 개체 / P2_R01-034 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-034 | C | {"type": "Point", "coordinates": [3.3903125, 20.278715932167728]} | 0.914162 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-035 | 관목 개체 / P2_R01-035 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-035 | C | {"type": "Point", "coordinates": [1.2653124999999998, 21.0148375253845]} | 0.959287 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-036 | 관목 개체 / P2_R01-036 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-036 | C | {"type": "Point", "coordinates": [2.1153125, 21.0148375253845]} | 0.946537 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-037 | 관목 개체 / P2_R01-037 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-037 | C | {"type": "Point", "coordinates": [2.9653125, 21.0148375253845]} | 0.933787 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-038 | 관목 개체 / P2_R01-038 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-038 | C | {"type": "Point", "coordinates": [1.6903124999999999, 21.750959118601273]} | 0.966163 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-039 | 관목 개체 / P2_R01-039 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-039 | C | {"type": "Point", "coordinates": [2.5403124999999998, 21.750959118601273]} | 0.953413 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-040 | 관목 개체 / P2_R01-040 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-040 | C | {"type": "Point", "coordinates": [1.2653124999999998, 22.487080711818045]} | 0.985788 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-041 | 관목 개체 / P2_R01-041 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-041 | C | {"type": "Point", "coordinates": [2.1153125, 22.487080711818045]} | 0.973038 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-042 | 관목 개체 / P2_R01-042 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-042 | C | {"type": "Point", "coordinates": [1.6903124999999999, 23.22320230503482]} | 0.992663 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-043 | 관목 개체 / P2_R01-043 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-043 | C | {"type": "Point", "coordinates": [2.5403124999999998, 23.22320230503482]} | 0.979913 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-044 | 관목 개체 / P2_R01-044 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-044 | C | {"type": "Point", "coordinates": [2.1153125, 23.959323898251593]} | 0.999538 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-045 | 관목 개체 / P2_R01-045 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-045 | C | {"type": "Point", "coordinates": [2.9653125, 23.959323898251593]} | 0.986788 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-046 | 관목 개체 / P2_R01-046 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-046 | C | {"type": "Point", "coordinates": [2.5403124999999998, 24.695445491468366]} | 1.00641 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R01-047 | 관목 개체 / P2_R01-047 | PK.50.40.C 관목 식재 / C구역 (관목 식재) | P2_R01-047 | C | {"type": "Point", "coordinates": [3.3903125, 24.695445491468366]} | 0.993663 | R01 | PK.50.40.C | PK.50.40.C;PK.70.10.C | C_check;C_shrubs
P2_R02-001 | 관목 개체 / P2_R02-001 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-001 | A | {"type": "Point", "coordinates": [2.045, 32.84424659321677]} | 1.16052 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-002 | 관목 개체 / P2_R02-002 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-002 | A | {"type": "Point", "coordinates": [2.895, 32.84424659321677]} | 1.14777 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-003 | 관목 개체 / P2_R02-003 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-003 | A | {"type": "Point", "coordinates": [3.745, 32.84424659321677]} | 1.13502 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-004 | 관목 개체 / P2_R02-004 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-004 | A | {"type": "Point", "coordinates": [1.62, 33.580368186433546]} | 1.18015 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-005 | 관목 개체 / P2_R02-005 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-005 | A | {"type": "Point", "coordinates": [2.47, 33.580368186433546]} | 1.1674 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-006 | 관목 개체 / P2_R02-006 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-006 | A | {"type": "Point", "coordinates": [3.3200000000000003, 33.580368186433546]} | 1.15465 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-007 | 관목 개체 / P2_R02-007 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-007 | A | {"type": "Point", "coordinates": [4.17, 33.580368186433546]} | 1.1419 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-008 | 관목 개체 / P2_R02-008 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-008 | A | {"type": "Point", "coordinates": [1.195, 34.31648977965032]} | 1.19977 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-009 | 관목 개체 / P2_R02-009 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-009 | A | {"type": "Point", "coordinates": [2.045, 34.31648977965032]} | 1.18702 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-010 | 관목 개체 / P2_R02-010 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-010 | A | {"type": "Point", "coordinates": [2.895, 34.31648977965032]} | 1.17427 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-011 | 관목 개체 / P2_R02-011 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-011 | A | {"type": "Point", "coordinates": [3.745, 34.31648977965032]} | 1.16152 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-012 | 관목 개체 / P2_R02-012 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-012 | A | {"type": "Point", "coordinates": [1.62, 35.05261137286709]} | 1.20665 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-013 | 관목 개체 / P2_R02-013 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-013 | A | {"type": "Point", "coordinates": [2.47, 35.05261137286709]} | 1.1939 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-014 | 관목 개체 / P2_R02-014 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-014 | A | {"type": "Point", "coordinates": [3.3200000000000003, 35.05261137286709]} | 1.18115 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-015 | 관목 개체 / P2_R02-015 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-015 | A | {"type": "Point", "coordinates": [1.195, 35.78873296608386]} | 1.22627 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-016 | 관목 개체 / P2_R02-016 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-016 | A | {"type": "Point", "coordinates": [2.045, 35.78873296608386]} | 1.21352 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-017 | 관목 개체 / P2_R02-017 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-017 | A | {"type": "Point", "coordinates": [2.895, 35.78873296608386]} | 1.20077 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-018 | 관목 개체 / P2_R02-018 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-018 | A | {"type": "Point", "coordinates": [3.745, 35.78873296608386]} | 1.18802 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-019 | 관목 개체 / P2_R02-019 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-019 | A | {"type": "Point", "coordinates": [1.62, 36.524854559300636]} | 1.23315 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-020 | 관목 개체 / P2_R02-020 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-020 | A | {"type": "Point", "coordinates": [1.195, 37.260976152517415]} | 1.25277 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-021 | 관목 개체 / P2_R02-021 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-021 | A | {"type": "Point", "coordinates": [1.62, 37.99709774573418]} | 1.25965 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-022 | 관목 개체 / P2_R02-022 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-022 | A | {"type": "Point", "coordinates": [2.045, 38.73321933895096]} | 1.26652 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-023 | 관목 개체 / P2_R02-023 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-023 | A | {"type": "Point", "coordinates": [2.895, 38.73321933895096]} | 1.25377 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-024 | 관목 개체 / P2_R02-024 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-024 | A | {"type": "Point", "coordinates": [3.745, 38.73321933895096]} | 1.24102 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-025 | 관목 개체 / P2_R02-025 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-025 | A | {"type": "Point", "coordinates": [1.62, 39.46934093216773]} | 1.28615 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-026 | 관목 개체 / P2_R02-026 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-026 | A | {"type": "Point", "coordinates": [2.47, 39.46934093216773]} | 1.2734 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-027 | 관목 개체 / P2_R02-027 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-027 | A | {"type": "Point", "coordinates": [3.3200000000000003, 39.46934093216773]} | 1.26065 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-028 | 관목 개체 / P2_R02-028 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-028 | A | {"type": "Point", "coordinates": [4.17, 39.46934093216773]} | 1.2479 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-029 | 관목 개체 / P2_R02-029 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-029 | A | {"type": "Point", "coordinates": [2.045, 40.205462525384505]} | 1.29302 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-030 | 관목 개체 / P2_R02-030 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-030 | A | {"type": "Point", "coordinates": [2.895, 40.205462525384505]} | 1.28027 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-031 | 관목 개체 / P2_R02-031 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-031 | A | {"type": "Point", "coordinates": [3.745, 40.205462525384505]} | 1.26752 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-032 | 관목 개체 / P2_R02-032 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-032 | A | {"type": "Point", "coordinates": [4.595, 40.205462525384505]} | 1.25477 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-033 | 관목 개체 / P2_R02-033 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-033 | A | {"type": "Point", "coordinates": [2.47, 40.94158411860128]} | 1.2999 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-034 | 관목 개체 / P2_R02-034 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-034 | A | {"type": "Point", "coordinates": [3.3200000000000003, 40.94158411860128]} | 1.28715 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-035 | 관목 개체 / P2_R02-035 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-035 | A | {"type": "Point", "coordinates": [4.17, 40.94158411860128]} | 1.2744 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-036 | 관목 개체 / P2_R02-036 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-036 | A | {"type": "Point", "coordinates": [2.895, 41.67770571181805]} | 1.30677 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R02-037 | 관목 개체 / P2_R02-037 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R02-037 | A | {"type": "Point", "coordinates": [3.745, 41.67770571181805]} | 1.29402 | R02 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-001 | 관목 개체 / P2_R03-001 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-001 | B | {"type": "Point", "coordinates": [22.37312500000001, 44.223934093216776]} | 1.06043 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-002 | 관목 개체 / P2_R03-002 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-002 | B | {"type": "Point", "coordinates": [23.22312500000001, 44.223934093216776]} | 1.04768 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-003 | 관목 개체 / P2_R03-003 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-003 | B | {"type": "Point", "coordinates": [24.07312500000001, 44.223934093216776]} | 1.03493 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-004 | 관목 개체 / P2_R03-004 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-004 | B | {"type": "Point", "coordinates": [24.923125000000013, 44.223934093216776]} | 1.02218 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-005 | 관목 개체 / P2_R03-005 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-005 | B | {"type": "Point", "coordinates": [25.773125000000014, 44.223934093216776]} | 1.00943 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-006 | 관목 개체 / P2_R03-006 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-006 | B | {"type": "Point", "coordinates": [26.623125000000016, 44.223934093216776]} | 0.996684 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-007 | 관목 개체 / P2_R03-007 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-007 | B | {"type": "Point", "coordinates": [27.473125000000017, 44.223934093216776]} | 0.983934 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-008 | 관목 개체 / P2_R03-008 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-008 | A | {"type": "Point", "coordinates": [9.198125, 44.96005568643355]} | 1.27131 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-009 | 관목 개체 / P2_R03-009 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-009 | A | {"type": "Point", "coordinates": [10.048124999999999, 44.96005568643355]} | 1.25856 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-010 | 관목 개체 / P2_R03-010 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-010 | A | {"type": "Point", "coordinates": [11.748124999999998, 44.96005568643355]} | 1.23306 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-011 | 관목 개체 / P2_R03-011 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-011 | A | {"type": "Point", "coordinates": [12.598124999999998, 44.96005568643355]} | 1.22031 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-012 | 관목 개체 / P2_R03-012 | PK.50.40.A 관목 식재 / A구역 (관목 식재) | P2_R03-012 | A | {"type": "Point", "coordinates": [13.448124999999997, 44.96005568643355]} | 1.20756 | R03 | PK.50.40.A | PK.50.40.A;PK.70.10.A | A_check;A_shrubs
P2_R03-013 | 관목 개체 / P2_R03-013 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-013 | B | {"type": "Point", "coordinates": [20.248125, 44.96005568643355]} | 1.10556 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-014 | 관목 개체 / P2_R03-014 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-014 | B | {"type": "Point", "coordinates": [21.098125000000003, 44.96005568643355]} | 1.09281 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-015 | 관목 개체 / P2_R03-015 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-015 | B | {"type": "Point", "coordinates": [21.948125000000005, 44.96005568643355]} | 1.08006 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
P2_R03-016 | 관목 개체 / P2_R03-016 | PK.50.40.B 관목 식재 / B구역 (관목 식재) | P2_R03-016 | B | {"type": "Point", "coordinates": [22.798125000000006, 44.96005568643355]} | 1.06731 | R03 | PK.50.40.B | PK.50.40.B;PK.70.10.B | B_check;B_shrubs
