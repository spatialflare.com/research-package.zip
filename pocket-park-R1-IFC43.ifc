Properties of the parts of a building model (IFC4X3_ADD2), part 7 of 9

# IfcTask: EXECUTABLE_TASK (62)
Name | Description | Identification = WBSCode | LongDescription | WorkMethod | PredefinedType | Classification | TaskJSON | ParentWBSCode | LegacyTaskId | WorkZones | ScopeObjectIds | WorkQuantity | WorkQuantityUnit | Status | CalculationJSON | PlannedNetWorkHours | Planned8HourCrewDays | SetupHours | TravelAllowanceHours | ResourceBundleJSON | EquipmentRequirement | IncludedWork | PrimaryCode | Title | Clauses | RelatedCodes | ApplicationNote | SourceURL
관목 식재 / A구역 | P2 작업 A_shrubs / 작업량 138 ea | PK.50.40.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / shrubs | INSTALLATION | PK.50.40.A 관목 식재 / A구역 (관목 식재); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "A_shrubs", "wbs_code": "PK.50.40.A", "zone_id": "A", "activity_type": "shrubs", "input_object_ids": [], "output_object_ids": ["P2_R02-001", "P2_R02-002", "P2_R02-003", "P2_R02-004", "P2_R02-005", "P2_R02-006", "P2_R02-007", "P2_R02-008", "P2_R02-009", "P2_R02-010", "P2_R02-011", "P2_R02-012", "P2_R02-013", "P2_R02-014", "P2_R02-015", "P2_R02-016", "P2_R02-017", "P2_R02-018", "P2_R02-019", "P2_R02-020", "P2_R02-021", "P2_R02-022", "P2_R02-023", "P2_R02-024", "P2_R02-025", "P2_R02-026", "P2_R02-027", "P2_R02-028", "P2_R02-029", "P2_R02-030", "P2_R02-031", "P2_R02-032", "P2_R02-033", "P2_R02-034", "P2_R02-035", "P2_R02-036", "P2_R02-037", "P2_R03-008", "P2_R03-009", "P2_R03-010", "P2_R03-011", "P2_R03-012", "P2_R03-025", "P2_R03-026", "P2_R03-027", "P2_R03-028", "P2_R03-029", "P2_R03-030", "P2_R03-031", "P2_R03-032", "P2_R03-033", "P2_R03-034", "P2_R03-035", "P2_R03-036", "P2_R03-050", "P2_R03-051", "P2_R03-052", "P2_R03-053", "P2_R03-054", "P2_R03-055", "P2_R03-056", "P2_R03-057", "P2_R03-058", "P2_R03-059", "P2_R03-060", "P2_R03-072", "P2_R03-073", "P2_R03-074", "P2_R03-075", "P2_R03-076", "P2_S02-005", "P2_S02-006", "P2_S02-007", "P2_S02-008", "P2_S02-009", "P2_S02-010", "P2_S02-011", "P2_S02-012", "P2_S02-013", "P2_S02-014", "P2_S02-026", "P2_S02-027", "P2_S02-028", "P2_S02-029", "P2_S02-030", "P2_S02-031", "P2_S02-032", "P2_S02-033", "P2_S02-034", "P2_S02-035", "P2_S02-036", "P2_S02-037", "P2_S02-038", "P2_S02-039", "P2_S02-040", "P2_S02-041", "P2_S02-052", "P2_S02-053", "P2_S02-054", "P2_S02-055", "P2_S02-056", "P2_S02-057", "P2_S02-058", "P2_S02-059", "P2_S02-060", "P2_S02-061", "P2_S02-062", "P2_S02-063", "P2_S02-064", "P2_S02-065", "P2_S02-066", "P2_S02-067", "P2_Y04-001", "P2_Y04-002", "P2_Y04-003", "P2_Y04-004", "P2_Y04-005", "P2_Y04-006", "P2_Y04-007", "P2_Y04-008", "P2_Y04-009", "P2_Y04-010", "P2_Y04-011", "P2_Y04-012", "P2_Y04-013", "P2_Y04-014", "P2_Y04-015", "P2_Y04-016", "P2_Y04-017", "P2_Y04-018", "P2_Y04-019", "P2_Y04-020", "P2_Y04-021", "P2_Y04-022", "P2_Y04-023", "P2_Y04-024", "P2_Y04-025", "P2_Y04-026"], "quantity": 138, "unit": "ea", "predecessors": ["A_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1}, "productivity": 9.375, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "53", "parent_wbs_code": "PK.50.40", "wbs_name": "관목 식재 / A구역", "task_guid": "3z0rsh1xfHIhyJPLV9W5WU", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"A_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149"], "norm_breakdown": [{"rate_key": "SHRUB_R", "quantity": 70, "daily_output": 75, "hours": 7.466666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 42, "daily_output": 75, "hours": 4.48, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 26, "daily_output": 75, "hours": 2.7733333333333334, "status": "SPEC_MATCHED"}], "norm_work_hours": 14.72, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 14.72, "planned_8h_crew_days": 1.84, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.40 | A_shrubs | A | ["ZONE_A"] | 138 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "SHRUB_R", "quantity": 70, "daily_output": 75, "hours": 7.466666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 42, "daily_output": 75, "hours": 4.48, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 26, "daily_output": 75, "hours": 2.7733333333333334, "status": "SPEC_MATCHED"}] | 14.72 | 1.84 | 0 | 0.03 | {"crew_landscaper": 3, "crew_general": 1} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 관목의 배식 간격·식재·관수. 품셈의 단식/군식 판정과 시방 적용은 서로 다른 정보이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149; NetCrewHours: 14.72
평떼 잔디붙임 / A구역 | P2 작업 A_turf / 작업량 286.004072 m2 | PK.50.50.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / turf | INSTALLATION | PK.50.50.A 평떼 잔디붙임 / A구역 (평떼 잔디붙임); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 25 잔디식재 (KCS 조경공사 표준시방서) | {"task_id": "A_turf", "wbs_code": "PK.50.50.A", "zone_id": "A", "activity_type": "turf", "input_object_ids": [], "output_object_ids": ["lawn_A"], "quantity": 286.0040716133794, "unit": "m2", "predecessors": ["A_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 4}, "productivity": 18.75, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "54", "parent_wbs_code": "PK.50.50", "wbs_name": "평떼 잔디붙임 / A구역", "task_guid": "2vCwpNLMPUVeYPeZCgPZF8", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"A_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-1-1 잔디붙임 / 인쇄91 / PDF147"], "norm_breakdown": [{"rate_key": "TURF", "quantity": 286.0040716133794, "daily_output": 150, "hours": 15.253550486046901, "status": "CONDITIONAL_METHOD"}], "norm_work_hours": 15.253550486046901, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 15.253550486046901, "planned_8h_crew_days": 1.9066938107558626, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.50 | A_turf | A | ["ZONE_A"] | 286.004 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "TURF", "quantity": 286.0040716133794, "daily_output": 150, "hours": 15.253550486046901, "status": "CONDITIONAL_METHOD"}] | 15.2536 | 1.90669 | 0 | 0.03 | {"crew_landscaper": 1, "crew_general": 4} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 25 | 잔디식재 | 2.1.1 잔디; 3.1.1 잔디식재 시공일반 | KCS 34 40 05; KCS 34 30 10 | 300×300mm 평떼 전면붙임. 반입 후 1일 이내 식재 조건을 고려한 반입 분할 계획은 아직 모델화하지 않았다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2025%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-1-1 잔디붙임 / 인쇄91 / PDF147; NetCrewHours: 15.2536
수목 하부 멀칭 / A구역 | P2 작업 A_mulch / 작업량 7.057234 m2 | PK.50.60.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / mulch | CONSTRUCTION | PK.50.60.A 수목 하부 멀칭 / A구역 (수목 하부 멀칭); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "A_mulch", "wbs_code": "PK.50.60.A", "zone_id": "A", "activity_type": "mulch", "input_object_ids": [], "output_object_ids": ["green_A"], "quantity": 7.057234103728366, "unit": "m2", "predecessors": ["A_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 25, "productivity_unit": "m2/crew_hour", "productivity_model_id": "mulch_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "55", "parent_wbs_code": "PK.50.60", "wbs_name": "수목 하부 멀칭 / A구역", "task_guid": "0qcn$1YPnK4RH8XJ8hOzYX", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.28228936414913464, "planned_8h_crew_days": 0.03528617051864183, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.50.60 | A_mulch | A | ["ZONE_A"] | 7.05723 | m2 | ASSUMED_NOT_VERIFIED | [] | 0.282289 | 0.0352862 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 2.2.1 멀칭재 | KCS 34 40 05 | 수목 하부 멀칭재 품질 기준. 두께·시공 범위는 설계 가정이며 해당 조항이 수치를 확정하지 않는다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10
벤치 설치 / A구역 | P2 작업 A_bench / 작업량 3 ea | PK.60.10.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / bench | INSTALLATION | PK.60.10.A 벤치 설치 / A구역 (벤치 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 50 15 현장제작설치 시설 (KCS 조경공사 표준시방서); KCS 34 50 20 옥외시설물 (KCS 조경공사 표준시방서) | {"task_id": "A_bench", "wbs_code": "PK.60.10.A", "zone_id": "A", "activity_type": "bench", "input_object_ids": [], "output_object_ids": ["BENCH03", "BENCH04", "BENCH05"], "quantity": 3, "unit": "ea", "predecessors": ["A_foundation", "A_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 0.5, "productivity_unit": "ea/crew_hour", "productivity_model_id": "bench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 24, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "60", "parent_wbs_code": "PK.60.10", "wbs_name": "벤치 설치 / A구역", "task_guid": "1JxWIS5BLTD9df1rvsFUAo", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_foundation": 24.0, "A_finish": 0.0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 6.0, "planned_8h_crew_days": 0.75, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.60.10 | A_bench | A | ["ZONE_A"] | 3 | ea | ASSUMED_NOT_VERIFIED | [] | 6 | 0.75 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 50 20 | 옥외시설물 | 2.1.11 옥외용 벤치; 3.2.2 의자 | KCS 34 50 05; KCS 34 50 15 | 벤치 높이·기초·앵커·체결·마감 확인. 재료별 관련 시방을 함께 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2050%2020%3A2024-12-10
구역 마무리 검사 / A구역 | P2 작업 A_check / 작업량 1 ea | PK.70.10.A | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / check | INSPECTION | PK.70.10.A 구역 마무리 검사 / A구역 (구역 마무리 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "A_check", "wbs_code": "PK.70.10.A", "zone_id": "A", "activity_type": "check", "input_object_ids": ["BENCH03", "BENCH04", "BENCH05", "CHAMBER_A", "CURB_A", "P2_D02", "P2_I04", "P2_I07", "P2_N02", "P2_R02-001", "P2_R02-002", "P2_R02-003", "P2_R02-004", "P2_R02-005", "P2_R02-006", "P2_R02-007", "P2_R02-008", "P2_R02-009", "P2_R02-010", "P2_R02-011", "P2_R02-012", "P2_R02-013", "P2_R02-014", "P2_R02-015", "P2_R02-016", "P2_R02-017", "P2_R02-018", "P2_R02-019", "P2_R02-020", "P2_R02-021", "P2_R02-022", "P2_R02-023", "P2_R02-024", "P2_R02-025", "P2_R02-026", "P2_R02-027", "P2_R02-028", "P2_R02-029", "P2_R02-030", "P2_R02-031", "P2_R02-032", "P2_R02-033", "P2_R02-034", "P2_R02-035", "P2_R02-036", "P2_R02-037", "P2_R03-008", "P2_R03-009", "P2_R03-010", "P2_R03-011", "P2_R03-012", "P2_R03-025", "P2_R03-026", "P2_R03-027", "P2_R03-028", "P2_R03-029", "P2_R03-030", "P2_R03-031", "P2_R03-032", "P2_R03-033", "P2_R03-034", "P2_R03-035", "P2_R03-036", "P2_R03-050", "P2_R03-051", "P2_R03-052", "P2_R03-053", "P2_R03-054", "P2_R03-055", "P2_R03-056", "P2_R03-057", "P2_R03-058", "P2_R03-059", "P2_R03-060", "P2_R03-072", "P2_R03-073", "P2_R03-074", "P2_R03-075", "P2_R03-076", "P2_S02-005", "P2_S02-006", "P2_S02-007", "P2_S02-008", "P2_S02-009", "P2_S02-010", "P2_S02-011", "P2_S02-012", "P2_S02-013", "P2_S02-014", "P2_S02-026", "P2_S02-027", "P2_S02-028", "P2_S02-029", "P2_S02-030", "P2_S02-031", "P2_S02-032", "P2_S02-033", "P2_S02-034", "P2_S02-035", "P2_S02-036", "P2_S02-037", "P2_S02-038", "P2_S02-039", "P2_S02-040", "P2_S02-041", "P2_S02-052", "P2_S02-053", "P2_S02-054", "P2_S02-055", "P2_S02-056", "P2_S02-057", "P2_S02-058", "P2_S02-059", "P2_S02-060", "P2_S02-061", "P2_S02-062", "P2_S02-063", "P2_S02-064", "P2_S02-065", "P2_S02-066", "P2_S02-067", "P2_Y04-001", "P2_Y04-002", "P2_Y04-003", "P2_Y04-004", "P2_Y04-005", "P2_Y04-006", "P2_Y04-007", "P2_Y04-008", "P2_Y04-009", "P2_Y04-010", "P2_Y04-011", "P2_Y04-012", "P2_Y04-013", "P2_Y04-014", "P2_Y04-015", "P2_Y04-016", "P2_Y04-017", "P2_Y04-018", "P2_Y04-019", "P2_Y04-020", "P2_Y04-021", "P2_Y04-022", "P2_Y04-023", "P2_Y04-024", "P2_Y04-025", "P2_Y04-026", "PIPE_A", "green_A", "lawn_A", "plaza_A", "shrub_A", "walkway_A"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["A_shrubs", "A_turf", "A_mulch", "A_bench"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 1, "productivity_unit": "ea/crew_hour", "productivity_model_id": "check_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_A", "work_zones": ["A"], "access_node_id": "A", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "70", "parent_wbs_code": "PK.70.10", "wbs_name": "구역 마무리 검사 / A구역", "task_guid": "0QpginrLjSj9CDjtEXJ5e4", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_A"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"A_shrubs": 0, "A_turf": 0, "A_mulch": 0, "A_bench": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.0, "planned_8h_crew_days": 0.125, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.10 | A_check | A | ["ZONE_A"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 1 | 0.125 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.6.2 품질시험·검사; 3.1.1 시공 확인 및 검사 | KCS 34 40 05; KCS 34 60 05; KCS 34 50 05 | 구역 종합검사 공통 기준. 해당 구역의 식재·포장·시설물 세부 기준을 함께 대조한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
관로·집수정 굴착 / B구역 | P2 작업 B_trench / 작업량 8.75 m3 | PK.20.10.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / trench | CONSTRUCTION | PK.20.10.B 관로·집수정 굴착 / B구역 (관로·집수정 굴착); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "B_trench", "wbs_code": "PK.20.10.B", "zone_id": "B", "activity_type": "trench", "input_object_ids": ["ZONE_B"], "output_object_ids": [], "quantity": 8.75, "unit": "m3", "predecessors": ["SITE_survey"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 4, "productivity_unit": "m3/crew_hour", "productivity_model_id": "trench_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "20", "parent_wbs_code": "PK.20.10", "wbs_name": "관로·집수정 굴착 / B구역", "task_guid": "3VQFKE61PQGAfmUUqZompD", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_survey": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 2.1875, "planned_8h_crew_days": 0.2734375, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.20.10 | B_trench | B | ["ZONE_B"] | 8.75 | m3 | ASSUMED_NOT_VERIFIED | [] | 2.1875 | 0.273438 | 0.2 | 0.15 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.2.1 준비배수; 3.3.1 땅깎기 | KCS 34 50 65 | 관로·집수정 굴착의 토공 기준. 흙막이 등은 지반·굴착 상세 확정 후 추가 검토한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
되메우기·다짐 / B구역 | P2 작업 B_backfill / 작업량 6.093681 m3 | PK.20.50.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / backfill | CONSTRUCTION | PK.20.50.B 되메우기·다짐 / B구역 (되메우기·다짐); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 50 65 조경 급․배수 및 관수 (KCS 조경공사 표준시방서) | {"task_id": "B_backfill", "wbs_code": "PK.20.50.B", "zone_id": "B", "activity_type": "backfill", "input_object_ids": ["ZONE_B"], "output_object_ids": [], "quantity": 6.093681493397524, "unit": "m3", "predecessors": ["SITE_draincheck"], "lag": 0, "required_resource_bundle": {"earth_crew": 1, "excavator": 1, "truck": 1}, "productivity": 6, "productivity_unit": "m3/crew_hour", "productivity_model_id": "backfill_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "24", "parent_wbs_code": "PK.20.50", "wbs_name": "되메우기·다짐 / B구역", "task_guid": "13T0myAS9R8wqFPwu8ct82", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"SITE_draincheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.0156135822329206, "planned_8h_crew_days": 0.12695169777911508, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.20.50 | B_backfill | B | ["ZONE_B"] | 6.09368 | m3 | ASSUMED_NOT_VERIFIED | [] | 1.01561 | 0.126952 | 0.2 | 0.15 | {"earth_crew": 1, "excavator": 1, "truck": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 20 10 | 조경 토공사 | 3.3.3 흙쌓기; 3.6.3 다짐도 검사 | KCS 34 50 65 | 관로 검사 후 되메우기·다짐. 매설 완료 후 접속부 확인·승인도 필요하다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2020%2010%3A2024-12-10
식재기반 정비 / B구역 | P2 작업 B_soil / 작업량 442.5 m2 | PK.50.20.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / soil | CONSTRUCTION | PK.50.20.B 식재기반 정비 / B구역 (식재기반 정비); KCS 34 20 10 조경 토공사 (KCS 조경공사 표준시방서); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서) | {"task_id": "B_soil", "wbs_code": "PK.50.20.B", "zone_id": "B", "activity_type": "soil", "input_object_ids": ["green_B", "lawn_B"], "output_object_ids": ["shrub_B"], "quantity": 442.50000000000006, "unit": "m2", "predecessors": ["B_curb"], "lag": 0, "required_resource_bundle": {"excavator": 1, "crew_landscaper": 1, "crew_general": 2}, "productivity": 45, "productivity_unit": "m2/crew_hour", "productivity_model_id": "soil_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "32", "parent_wbs_code": "PK.50.20", "wbs_name": "식재기반 정비 / B구역", "task_guid": "0hBqgI0_nK_8KlMb1sbLCd", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"B_curb": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 9.833333333333334, "planned_8h_crew_days": 1.2291666666666667, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.50.20 | B_soil | B | ["ZONE_B"] | 442.5 | m2 | ASSUMED_NOT_VERIFIED | [] | 9.83333 | 1.22917 | 0.2 | 0.15 | {"excavator": 1, "crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 30 10 | 식재기반 조성 | 2.1 토양 관련 재료; 3.1.1 일반식재기반 조성 | KCS 34 20 10; KCS 34 40 05 | 식재용 토양·유효토심·배수 기반 검토. 토양 시험 및 현장 적합성은 미확인이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2030%2010%3A2024-12-10
교목 식재(구덩이 포함) / B구역 | P2 작업 B_trees / 작업량 6 ea | PK.50.30.B | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / trees | INSTALLATION | PK.50.30.B 교목 식재(구덩이 포함) / B구역 (교목 식재(구덩이 포함)); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "B_trees", "wbs_code": "PK.50.30.B", "zone_id": "B", "activity_type": "trees", "input_object_ids": [], "output_object_ids": ["P2_D01", "P2_I05", "P2_N03", "P2_T01", "P2_T02", "P2_T03"], "quantity": 6, "unit": "ea", "predecessors": ["B_soil"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1, "excavator": 1}, "productivity": 2.4029126213592233, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 16, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "33", "parent_wbs_code": "PK.50.30", "wbs_name": "교목 식재(구덩이 포함) / B구역", "task_guid": "24LdlA5grQvwnUaOYHVOox", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"B_soil": 0}, "included_pit_volume_m3": 3.0581347782822905, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-3-4 교목식재(수고) / 인쇄96 / PDF152", "공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152"], "norm_breakdown": [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_T", "quantity": 3, "daily_output": 30, "hours": 0.8, "status": "CONDITIONAL_HEIGHT"}], "norm_work_hours": 2.496969696969697, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제", "planned_net_work_hours": 2.496969696969697, "planned_8h_crew_days": 0.31212121212121213, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.50.30 | B_trees | B | ["ZONE_B"] | 6 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "TREE_D", "quantity": 1, "daily_output": 22, "hours": 0.36363636363636365, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_I", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_N", "quantity": 1, "daily_output": 12, "hours": 0.6666666666666666, "status": "SPEC_MATCHED"}, {"rate_key": "TREE_T", "quantity": 3, "daily_output": 30, "hours": 0.8, "status": "CONDITIONAL_HEIGHT"}] | 2.49697 | 0.312121 | 0 | 0.15 | {"crew_landscaper": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 식재구덩이 터파기·식재·되메우기·초기관수·지주목; 별도 pits 작업 삭제 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.5 지주세우기; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 신규 교목의 굴착·식재·지주·관수. 규격·분 상태·식재시기를 함께 확인한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-3-4 교목식재(수고) / 인쇄96 / PDF152; 공통 4-3-5 교목식재(흉고직경/근원직경) / 인쇄96 / PDF152; NetCrewHours: 2.49697
화강석 경계석 설치 / B구역 | P2 작업 B_curb / 작업량 50.0 m | PK.30.20.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / curb | INSTALLATION | PK.30.20.B 화강석 경계석 설치 / B구역 (화강석 경계석 설치); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "B_curb", "wbs_code": "PK.30.20.B", "zone_id": "B", "activity_type": "curb", "input_object_ids": [], "output_object_ids": ["CURB_B"], "quantity": 50.0, "unit": "m", "predecessors": ["B_backfill"], "lag": 0, "required_resource_bundle": {"crew_special": 3, "crew_general": 1, "excavator": 1}, "productivity": 16.25, "productivity_unit": "m/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "39", "parent_wbs_code": "PK.30.20", "wbs_name": "화강석 경계석 설치 / B구역", "task_guid": "3S9A7ncEzPFhZ7Ppmow_zB", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"B_backfill": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385"], "norm_breakdown": [{"rate_key": "CURB_A", "quantity": 50.0, "daily_output": 130, "hours": 3.076923076923077, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 3.076923076923077, "equipment_requirement": "굴착기 0.4㎥ 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 3.076923076923077, "planned_8h_crew_days": 0.38461538461538464, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.30.20 | B_curb | B | ["ZONE_B"] | 50 | m | 2026_NORM_CONDITIONAL | [{"rate_key": "CURB_A", "quantity": 50.0, "daily_output": 130, "hours": 3.076923076923077, "status": "CONDITIONAL_SITE"}] | 3.07692 | 0.384615 | 0 | 0.15 | {"crew_special": 3, "crew_general": 1, "excavator": 1} | 굴착기 0.4㎥ 1대 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 25 | 조경포장경계 | 3.1.1 토공 및 기초; 3.1.2 경계블록 | KCS 34 60 05; KCS 34 50 05 | 화강석 경계석 선형·높이·기초·줄눈·뒤채움. 기초 콘크리트 물량과 강도 확보 대기는 현재 미확정이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2025%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-9-2 보차도 및 도로경계블록 설치 / 인쇄329 / PDF385; NetCrewHours: 3.07692
쇄석 포장기층 / B구역 | P2 작업 B_subbase / 작업량 50.0 m2 | PK.40.10.B | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / subbase | CONSTRUCTION | PK.40.10.B 쇄석 포장기층 / B구역 (쇄석 포장기층); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "B_subbase", "wbs_code": "PK.40.10.B", "zone_id": "B", "activity_type": "subbase", "input_object_ids": ["walkway_B"], "output_object_ids": [], "quantity": 50.0, "unit": "m2", "predecessors": ["B_curb", "B_trees"], "lag": 0, "required_resource_bundle": {"crew_paver": 2, "crew_special": 2, "crew_general": 1}, "productivity": 18, "productivity_unit": "m2/crew_hour", "productivity_model_id": "subbase_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "40", "parent_wbs_code": "PK.40.10", "wbs_name": "쇄석 포장기층 / B구역", "task_guid": "0YMNSLFZLNwOb8tVCDs4aE", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"B_curb": 0, "B_trees": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정.", "planned_net_work_hours": 2.7777777777777777, "planned_8h_crew_days": 0.3472222222222222, "setup_hours": 0.2, "travel_allowance_hours": 0.15} | PK.40.10 | B_subbase | B | ["ZONE_B"] | 50 | m2 | ASSUMED_NOT_VERIFIED | [] | 2.77778 | 0.347222 | 0.2 | 0.15 | {"crew_paver": 2, "crew_special": 2, "crew_general": 1} | 기존 합성모델 장비 가정 | 쇄석 기층만. 깔기모래는 finish에 통합; 기층 생산성 18㎡/h는 미검증 가정. | KCS 34 60 05 | 조경포장공통 | 3.3.3 원지반 정지 및 다짐; 3.3.4 쇄석기층 | KCS 34 60 15 | 블록포장 하부의 쇄석기층. 두께·다짐도·계획고를 검측한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
포장 기층 검사 / B구역 | P2 작업 B_pavecheck / 작업량 1 ea | PK.40.20.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / pavecheck | INSPECTION | PK.40.20.B 포장 기층 검사 / B구역 (포장 기층 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서) | {"task_id": "B_pavecheck", "wbs_code": "PK.40.20.B", "zone_id": "B", "activity_type": "pavecheck", "input_object_ids": ["walkway_B"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["B_subbase"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 2, "productivity_unit": "ea/crew_hour", "productivity_model_id": "pavecheck_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "41", "parent_wbs_code": "PK.40.20", "wbs_name": "포장 기층 검사 / B구역", "task_guid": "0wE8rrGgXG193rmP_zS3MK", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"B_subbase": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.5, "planned_8h_crew_days": 0.0625, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.40.20 | B_pavecheck | B | ["ZONE_B"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 0.5 | 0.0625 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 60 05 | 조경포장공통 | 3.4 시공허용오차; 3.6 현장품질관리 | KCS 34 60 15; KCS 34 10 10 | 포장 기층 검사. 시험·검측을 통과했다는 의미가 아닌 기준 연결이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2005%3A2024-12-10
모래·콘크리트블록 포장 / B구역 | P2 작업 B_finish / 작업량 50.0 m2 | PK.40.30.B | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / finish | CONSTRUCTION | PK.40.30.B 모래·콘크리트블록 포장 / B구역 (모래·콘크리트블록 포장); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서); KCS 34 60 15 친환경블록포장 (KCS 조경공사 표준시방서); KCS 34 60 25 조경포장경계 (KCS 조경공사 표준시방서) | {"task_id": "B_finish", "wbs_code": "PK.40.30.B", "zone_id": "B", "activity_type": "finish", "input_object_ids": [], "output_object_ids": ["walkway_B"], "quantity": 50.0, "unit": "m2", "predecessors": ["B_pavecheck"], "lag": 0, "required_resource_bundle": {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1}, "productivity": 37.5, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.15, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": true, "closes": "B", "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "42", "parent_wbs_code": "PK.40.30", "wbs_name": "모래·콘크리트블록 포장 / B구역", "task_guid": "0DRinPDDjLLRxqR$W4uAZ_", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"B_pavecheck": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374"], "norm_breakdown": [{"rate_key": "PAVING_A", "quantity": 50.0, "daily_output": 300, "hours": 1.3333333333333333, "status": "CONDITIONAL_SITE"}], "norm_work_hours": 1.3333333333333333, "equipment_requirement": "굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "깔기모래·블록 절단 및 설치·줄눈채움·후다짐", "planned_net_work_hours": 1.3333333333333333, "planned_8h_crew_days": 0.16666666666666666, "setup_hours": 0, "travel_allowance_hours": 0.15} | PK.40.30 | B_finish | B | ["ZONE_B"] | 50 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "PAVING_A", "quantity": 50.0, "daily_output": 300, "hours": 1.3333333333333333, "status": "CONDITIONAL_SITE"}] | 1.33333 | 0.166667 | 0 | 0.15 | {"crew_paver": 3, "crew_special": 2, "crew_general": 2, "excavator": 1, "plate_compactor": 1} | 굴착기 0.6㎥ 1대 + 플레이트콤팩터 1.5ton 1대 | 깔기모래·블록 절단 및 설치·줄눈채움·후다짐 | KCS 34 60 15 | 친환경블록포장 | 2.1.1 소형고압블록; 3.2.2 소형고압블록포장 | KCS 34 60 05; KCS 34 60 25 | 200×200mm 콘크리트블록을 소형고압블록 계열로 잠정 매칭. 제품 KS·물성은 자재 승인 시 확정한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2060%2015%3A2024-12-10 | LCS_WorkNorm - References: 토목 1-7-1 보도용 블록 설치(소형) / 인쇄318 / PDF374; NetCrewHours: 1.33333
관목 식재 / B구역 | P2 작업 B_shrubs / 작업량 221 ea | PK.50.40.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / shrubs | INSTALLATION | PK.50.40.B 관목 식재 / B구역 (관목 식재); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "B_shrubs", "wbs_code": "PK.50.40.B", "zone_id": "B", "activity_type": "shrubs", "input_object_ids": [], "output_object_ids": ["P2_R03-001", "P2_R03-002", "P2_R03-003", "P2_R03-004", "P2_R03-005", "P2_R03-006", "P2_R03-007", "P2_R03-013", "P2_R03-014", "P2_R03-015", "P2_R03-016", "P2_R03-017", "P2_R03-018", "P2_R03-019", "P2_R03-020", "P2_R03-021", "P2_R03-022", "P2_R03-023", "P2_R03-024", "P2_R03-037", "P2_R03-038", "P2_R03-039", "P2_R03-040", "P2_R03-041", "P2_R03-042", "P2_R03-043", "P2_R03-044", "P2_R03-045", "P2_R03-046", "P2_R03-047", "P2_R03-048", "P2_R03-049", "P2_R03-061", "P2_R03-062", "P2_R03-063", "P2_R03-064", "P2_R03-065", "P2_R03-066", "P2_R03-067", "P2_R03-068", "P2_R03-069", "P2_R03-070", "P2_R03-071", "P2_S01-003", "P2_S01-004", "P2_S01-005", "P2_S01-006", "P2_S01-007", "P2_S01-008", "P2_S01-009", "P2_S01-010", "P2_S01-011", "P2_S01-012", "P2_S01-013", "P2_S01-014", "P2_S01-015", "P2_S01-016", "P2_S01-017", "P2_S01-018", "P2_S01-019", "P2_S01-020", "P2_S01-021", "P2_S01-022", "P2_S01-023", "P2_S01-024", "P2_S01-025", "P2_S01-026", "P2_S01-027", "P2_S01-028", "P2_S01-029", "P2_S01-030", "P2_S01-031", "P2_S01-032", "P2_S01-033", "P2_S01-034", "P2_S01-035", "P2_S01-036", "P2_S01-037", "P2_S01-038", "P2_S01-039", "P2_S01-040", "P2_S01-041", "P2_S01-042", "P2_S01-043", "P2_S01-044", "P2_S01-045", "P2_S01-046", "P2_S01-047", "P2_S01-048", "P2_S01-049", "P2_S01-050", "P2_S01-051", "P2_S01-052", "P2_S01-053", "P2_S01-054", "P2_S01-055", "P2_S01-056", "P2_S01-057", "P2_S01-058", "P2_S01-059", "P2_S01-060", "P2_S01-061", "P2_S01-062", "P2_S01-063", "P2_S01-064", "P2_S01-065", "P2_S01-066", "P2_S01-067", "P2_S01-068", "P2_S01-069", "P2_S01-070", "P2_S01-071", "P2_S01-072", "P2_S01-073", "P2_S01-074", "P2_S01-075", "P2_S01-076", "P2_S01-077", "P2_S01-078", "P2_S01-079", "P2_S01-080", "P2_S01-081", "P2_S01-082", "P2_S01-083", "P2_S01-084", "P2_S01-085", "P2_S01-086", "P2_S01-087", "P2_S01-088", "P2_S01-089", "P2_S01-090", "P2_S01-091", "P2_S01-092", "P2_S01-093", "P2_S01-094", "P2_S01-095", "P2_S02-001", "P2_S02-002", "P2_S02-003", "P2_S02-004", "P2_S02-015", "P2_S02-016", "P2_S02-017", "P2_S02-018", "P2_S02-019", "P2_S02-020", "P2_S02-021", "P2_S02-022", "P2_S02-023", "P2_S02-024", "P2_S02-025", "P2_S02-042", "P2_S02-043", "P2_S02-044", "P2_S02-045", "P2_S02-046", "P2_S02-047", "P2_S02-048", "P2_S02-049", "P2_S02-050", "P2_S02-051", "P2_S02-068", "P2_S02-069", "P2_S02-070", "P2_S02-071", "P2_S02-072", "P2_S02-073", "P2_S02-074", "P2_S02-075", "P2_S02-076", "P2_S02-077", "P2_S02-078", "P2_S02-079", "P2_S02-080", "P2_S02-081", "P2_S02-082", "P2_Y05-004", "P2_Y05-005", "P2_Y05-006", "P2_Y05-007", "P2_Y05-008", "P2_Y05-009", "P2_Y05-010", "P2_Y05-011", "P2_Y05-012", "P2_Y05-013", "P2_Y05-014", "P2_Y05-015", "P2_Y05-016", "P2_Y05-017", "P2_Y05-018", "P2_Y05-019", "P2_Y05-020", "P2_Y05-021", "P2_Y05-022", "P2_Y05-023", "P2_Y05-024", "P2_Y05-025", "P2_Y05-026", "P2_Y05-027", "P2_Y05-028", "P2_Y05-029", "P2_Y05-030", "P2_Y05-031", "P2_Y05-032", "P2_Y05-033", "P2_Y05-034", "P2_Y05-035", "P2_Y05-036", "P2_Y05-037", "P2_Y05-038", "P2_Y05-039", "P2_Y05-040", "P2_Y05-041", "P2_Y05-042", "P2_Y05-043", "P2_Y05-044", "P2_Y05-045", "P2_Y05-046", "P2_Y05-047", "P2_Y05-048"], "quantity": 221, "unit": "ea", "predecessors": ["B_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 3, "crew_general": 1}, "productivity": 9.375, "productivity_unit": "ea/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "53", "parent_wbs_code": "PK.50.40", "wbs_name": "관목 식재 / B구역", "task_guid": "0C8tSAGf9OcwiEKQo3xru7", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"B_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149"], "norm_breakdown": [{"rate_key": "SHRUB_R", "quantity": 43, "daily_output": 75, "hours": 4.586666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 133, "daily_output": 75, "hours": 14.186666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 45, "daily_output": 75, "hours": 4.8, "status": "SPEC_MATCHED"}], "norm_work_hours": 23.573333333333334, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 23.573333333333334, "planned_8h_crew_days": 2.9466666666666668, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.40 | B_shrubs | B | ["ZONE_B"] | 221 | ea | 2026_NORM_CONDITIONAL | [{"rate_key": "SHRUB_R", "quantity": 43, "daily_output": 75, "hours": 4.586666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_S", "quantity": 133, "daily_output": 75, "hours": 14.186666666666667, "status": "SPEC_MATCHED"}, {"rate_key": "SHRUB_Y", "quantity": 45, "daily_output": 75, "hours": 4.8, "status": "SPEC_MATCHED"}] | 23.5733 | 2.94667 | 0 | 0.03 | {"crew_landscaper": 3, "crew_general": 1} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 3.1.1 식재구덩이 굴착; 3.1.3 식재; 3.1.7 관수 | KCS 34 40 05; KCS 34 30 10 | 관목의 배식 간격·식재·관수. 품셈의 단식/군식 판정과 시방 적용은 서로 다른 정보이다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-2-2 관목식재(단식) / 인쇄93 / PDF149; NetCrewHours: 23.5733
평떼 잔디붙임 / B구역 | P2 작업 B_turf / 작업량 275.214236 m2 | PK.50.50.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | 2026_NORM_CONDITIONAL / turf | INSTALLATION | PK.50.50.B 평떼 잔디붙임 / B구역 (평떼 잔디붙임); KCS 34 30 10 식재기반 조성 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 25 잔디식재 (KCS 조경공사 표준시방서) | {"task_id": "B_turf", "wbs_code": "PK.50.50.B", "zone_id": "B", "activity_type": "turf", "input_object_ids": [], "output_object_ids": ["lawn_B"], "quantity": 275.21423617506696, "unit": "m2", "predecessors": ["B_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 4}, "productivity": 18.75, "productivity_unit": "m2/crew_hour", "productivity_model_id": "PUMSEM2026_WEIGHTED_SPEC_A", "fixed_setup_time": 0, "travel_hours": 0.03, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "SOURCE_BASED_WITH_SITE_ASSUMPTIONS", "legacy_priority_code": "54", "parent_wbs_code": "PK.50.50", "wbs_name": "평떼 잔디붙임 / B구역", "task_guid": "2T1IF9gVHSD82oYe08_sRB", "ifc_predefined_type": "INSTALLATION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 geometry quantities; work time = sum(quantity per specification / daily crew output) × 8", "classification_version": "R1-WBS2", "predecessor_lags": {"B_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "2026_NORM_CONDITIONAL", "norm_references": ["공통 4-1-1 잔디붙임 / 인쇄91 / PDF147"], "norm_breakdown": [{"rate_key": "TURF", "quantity": 275.21423617506696, "daily_output": 150, "hours": 14.678092596003571, "status": "CONDITIONAL_METHOD"}], "norm_work_hours": 14.678092596003571, "equipment_requirement": "품셈 표상 장비 없음", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "setup_basis": "별도 준비시간 0: 품셈 일당시공량에 추가 일률 가산하지 않음. 구역 이동시간은 모델 가정으로 별도.", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 14.678092596003571, "planned_8h_crew_days": 1.8347615745004464, "setup_hours": 0, "travel_allowance_hours": 0.03} | PK.50.50 | B_turf | B | ["ZONE_B"] | 275.214 | m2 | 2026_NORM_CONDITIONAL | [{"rate_key": "TURF", "quantity": 275.21423617506696, "daily_output": 150, "hours": 14.678092596003571, "status": "CONDITIONAL_METHOD"}] | 14.6781 | 1.83476 | 0 | 0.03 | {"crew_landscaper": 1, "crew_general": 4} | 품셈 표상 장비 없음 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 25 | 잔디식재 | 2.1.1 잔디; 3.1.1 잔디식재 시공일반 | KCS 34 40 05; KCS 34 30 10 | 300×300mm 평떼 전면붙임. 반입 후 1일 이내 식재 조건을 고려한 반입 분할 계획은 아직 모델화하지 않았다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2025%3A2024-12-10 | LCS_WorkNorm - References: 공통 4-1-1 잔디붙임 / 인쇄91 / PDF147; NetCrewHours: 14.6781
수목 하부 멀칭 / B구역 | P2 작업 B_mulch / 작업량 10.585851 m2 | PK.50.60.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / mulch | CONSTRUCTION | PK.50.60.B 수목 하부 멀칭 / B구역 (수목 하부 멀칭); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 40 10 일반식재기반 식재 (KCS 조경공사 표준시방서) | {"task_id": "B_mulch", "wbs_code": "PK.50.60.B", "zone_id": "B", "activity_type": "mulch", "input_object_ids": [], "output_object_ids": ["green_B"], "quantity": 10.585851155592552, "unit": "m2", "predecessors": ["B_finish"], "lag": 0, "required_resource_bundle": {"crew_landscaper": 1, "crew_general": 2}, "productivity": 25, "productivity_unit": "m2/crew_hour", "productivity_model_id": "mulch_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": false, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "55", "parent_wbs_code": "PK.50.60", "wbs_name": "수목 하부 멀칭 / B구역", "task_guid": "34hj5tkgTNLQ5jAjR8d_3I", "ifc_predefined_type": "CONSTRUCTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"B_finish": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 0.42343404622370207, "planned_8h_crew_days": 0.05292925577796276, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.50.60 | B_mulch | B | ["ZONE_B"] | 10.5859 | m2 | ASSUMED_NOT_VERIFIED | [] | 0.423434 | 0.0529293 | 0.2 | 0.03 | {"crew_landscaper": 1, "crew_general": 2} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 40 10 | 일반식재기반 식재 | 2.2.1 멀칭재 | KCS 34 40 05 | 수목 하부 멀칭재 품질 기준. 두께·시공 범위는 설계 가정이며 해당 조항이 수치를 확정하지 않는다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2040%2010%3A2024-12-10
구역 마무리 검사 / B구역 | P2 작업 B_check / 작업량 1 ea | PK.70.10.B | 기존 작업 범위; 세부 내역은 검토서 참조 / 장비접근·누락 기초 상세 미확정. 실행 공기 확정값 아님. | ASSUMED_NOT_VERIFIED / check | INSPECTION | PK.70.10.B 구역 마무리 검사 / B구역 (구역 마무리 검사); KCS 34 10 10 조경공사 일반 (KCS 조경공사 표준시방서); KCS 34 40 05 식재공통 (KCS 조경공사 표준시방서); KCS 34 50 05 조경시설물공통 (KCS 조경공사 표준시방서); KCS 34 60 05 조경포장공통 (KCS 조경공사 표준시방서) | {"task_id": "B_check", "wbs_code": "PK.70.10.B", "zone_id": "B", "activity_type": "check", "input_object_ids": ["CHAMBER_B", "CURB_B", "P2_D01", "P2_I05", "P2_N03", "P2_R03-001", "P2_R03-002", "P2_R03-003", "P2_R03-004", "P2_R03-005", "P2_R03-006", "P2_R03-007", "P2_R03-013", "P2_R03-014", "P2_R03-015", "P2_R03-016", "P2_R03-017", "P2_R03-018", "P2_R03-019", "P2_R03-020", "P2_R03-021", "P2_R03-022", "P2_R03-023", "P2_R03-024", "P2_R03-037", "P2_R03-038", "P2_R03-039", "P2_R03-040", "P2_R03-041", "P2_R03-042", "P2_R03-043", "P2_R03-044", "P2_R03-045", "P2_R03-046", "P2_R03-047", "P2_R03-048", "P2_R03-049", "P2_R03-061", "P2_R03-062", "P2_R03-063", "P2_R03-064", "P2_R03-065", "P2_R03-066", "P2_R03-067", "P2_R03-068", "P2_R03-069", "P2_R03-070", "P2_R03-071", "P2_S01-003", "P2_S01-004", "P2_S01-005", "P2_S01-006", "P2_S01-007", "P2_S01-008", "P2_S01-009", "P2_S01-010", "P2_S01-011", "P2_S01-012", "P2_S01-013", "P2_S01-014", "P2_S01-015", "P2_S01-016", "P2_S01-017", "P2_S01-018", "P2_S01-019", "P2_S01-020", "P2_S01-021", "P2_S01-022", "P2_S01-023", "P2_S01-024", "P2_S01-025", "P2_S01-026", "P2_S01-027", "P2_S01-028", "P2_S01-029", "P2_S01-030", "P2_S01-031", "P2_S01-032", "P2_S01-033", "P2_S01-034", "P2_S01-035", "P2_S01-036", "P2_S01-037", "P2_S01-038", "P2_S01-039", "P2_S01-040", "P2_S01-041", "P2_S01-042", "P2_S01-043", "P2_S01-044", "P2_S01-045", "P2_S01-046", "P2_S01-047", "P2_S01-048", "P2_S01-049", "P2_S01-050", "P2_S01-051", "P2_S01-052", "P2_S01-053", "P2_S01-054", "P2_S01-055", "P2_S01-056", "P2_S01-057", "P2_S01-058", "P2_S01-059", "P2_S01-060", "P2_S01-061", "P2_S01-062", "P2_S01-063", "P2_S01-064", "P2_S01-065", "P2_S01-066", "P2_S01-067", "P2_S01-068", "P2_S01-069", "P2_S01-070", "P2_S01-071", "P2_S01-072", "P2_S01-073", "P2_S01-074", "P2_S01-075", "P2_S01-076", "P2_S01-077", "P2_S01-078", "P2_S01-079", "P2_S01-080", "P2_S01-081", "P2_S01-082", "P2_S01-083", "P2_S01-084", "P2_S01-085", "P2_S01-086", "P2_S01-087", "P2_S01-088", "P2_S01-089", "P2_S01-090", "P2_S01-091", "P2_S01-092", "P2_S01-093", "P2_S01-094", "P2_S01-095", "P2_S02-001", "P2_S02-002", "P2_S02-003", "P2_S02-004", "P2_S02-015", "P2_S02-016", "P2_S02-017", "P2_S02-018", "P2_S02-019", "P2_S02-020", "P2_S02-021", "P2_S02-022", "P2_S02-023", "P2_S02-024", "P2_S02-025", "P2_S02-042", "P2_S02-043", "P2_S02-044", "P2_S02-045", "P2_S02-046", "P2_S02-047", "P2_S02-048", "P2_S02-049", "P2_S02-050", "P2_S02-051", "P2_S02-068", "P2_S02-069", "P2_S02-070", "P2_S02-071", "P2_S02-072", "P2_S02-073", "P2_S02-074", "P2_S02-075", "P2_S02-076", "P2_S02-077", "P2_S02-078", "P2_S02-079", "P2_S02-080", "P2_S02-081", "P2_S02-082", "P2_T01", "P2_T02", "P2_T03", "P2_Y05-004", "P2_Y05-005", "P2_Y05-006", "P2_Y05-007", "P2_Y05-008", "P2_Y05-009", "P2_Y05-010", "P2_Y05-011", "P2_Y05-012", "P2_Y05-013", "P2_Y05-014", "P2_Y05-015", "P2_Y05-016", "P2_Y05-017", "P2_Y05-018", "P2_Y05-019", "P2_Y05-020", "P2_Y05-021", "P2_Y05-022", "P2_Y05-023", "P2_Y05-024", "P2_Y05-025", "P2_Y05-026", "P2_Y05-027", "P2_Y05-028", "P2_Y05-029", "P2_Y05-030", "P2_Y05-031", "P2_Y05-032", "P2_Y05-033", "P2_Y05-034", "P2_Y05-035", "P2_Y05-036", "P2_Y05-037", "P2_Y05-038", "P2_Y05-039", "P2_Y05-040", "P2_Y05-041", "P2_Y05-042", "P2_Y05-043", "P2_Y05-044", "P2_Y05-045", "P2_Y05-046", "P2_Y05-047", "P2_Y05-048", "PIPE_B", "green_B", "lawn_B", "shrub_B", "walkway_B"], "output_object_ids": [], "quantity": 1, "unit": "ea", "predecessors": ["B_shrubs", "B_turf", "B_mulch"], "lag": 0, "required_resource_bundle": {"inspector": 1}, "productivity": 1, "productivity_unit": "ea/crew_hour", "productivity_model_id": "check_ASSUMED", "fixed_setup_time": 0.2, "travel_hours": 0.03, "work_polygon_id": "ZONE_B", "work_zones": ["B"], "access_node_id": "B", "heavy": false, "closes": null, "conflict_class": "exclusive_all_work_zones", "material_release_hour": 0, "material_requirement": "ASSUMED", "calendar_id": "WEEKDAY_8H", "weather_rule": "STOP_RAIN", "interrupt_policy": "RESUME_REMAINDER", "inspection_gate": true, "cost_rule_id": "FULL_SHIFT_RETAINED", "quantity_source": "IFC_ROUNDTRIP", "rule_version": "aggregate-P2-0.3", "provenance_status": "ASSUMED", "legacy_priority_code": "70", "parent_wbs_code": "PK.70.10", "wbs_name": "구역 마무리 검사 / B구역", "task_guid": "3n7dHmu61RGOxSFzmYZMsK", "ifc_predefined_type": "INSPECTION", "scope_object_ids": ["ZONE_B"], "quantity_basis": "R1 recalculated geometry; whole-site earthworks and connected drainage", "classification_version": "R1-WBS2", "predecessor_lags": {"B_shrubs": 0, "B_turf": 0, "B_mulch": 0}, "sequence_version": "R1-WBS2-PUMSEM2026", "norm_status": "ASSUMED_NOT_VERIFIED", "norm_references": [], "norm_breakdown": [], "norm_work_hours": null, "equipment_requirement": "기존 합성모델 장비 가정", "small_work_rule": "복합 공종 가정: 1-2-9 주④에 따라 할증 미적용; 구역별 최소일 반올림 없음", "included_work": "기존 작업 범위; 세부 내역은 검토서 참조", "planned_net_work_hours": 1.0, "planned_8h_crew_days": 0.125, "setup_hours": 0.2, "travel_allowance_hours": 0.03} | PK.70.10 | B_check | B | ["ZONE_B"] | 1 | ea | ASSUMED_NOT_VERIFIED | [] | 1 | 0.125 | 0.2 | 0.03 | {"inspector": 1} | 기존 합성모델 장비 가정 | 기존 작업 범위; 세부 내역은 검토서 참조 | KCS 34 10 10 | 조경공사 일반 | 1.6.2 품질시험·검사; 3.1.1 시공 확인 및 검사 | KCS 34 40 05; KCS 34 60 05; KCS 34 50 05 | 구역 종합검사 공통 기준. 해당 구역의 식재·포장·시설물 세부 기준을 함께 대조한다. | https://www.kcsc.re.kr/standardCode/viewer/KCS%2034%2010%2010%3A2024-12-10
